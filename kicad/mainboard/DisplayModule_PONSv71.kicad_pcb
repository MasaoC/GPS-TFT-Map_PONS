# Repository MasaoC/GPS-TFT-Map_PONS

File README.md (part):

# PONS — 鳥人間コンテスト向け 人力飛行機用 GPS/GNSS ナビ（航法装置）v7.1

**PONS（Pilot Oriented Navigation System）**は、人力飛行機のパイロットが使いやすいことを目標とした航法装置です。琵琶湖の鳥人間コンテストに特化しています。  
鳥人間チームの電装（パイロット用の計器・GPS ナビ）として、地図・対地速度・方位・姿勢・昇降計（バリオ）・風向風速を 1 つの画面と音声で伝えます。
基板（KiCad）・ファームウェア（Arduino）・3D プリントケースのデータをオープンソースで公開しています。  
GPS/GNSS navigation for human-powered aircraft, specialized for the Japan International Birdman Rally at Lake Biwa, Japan. → [English summary](#english-summary)

* **使用実績**：大阪大学 albatross（2024 追走ボート: v3 / 2025 追走ボート: v4 / 2025 機体搭載「白夜」: v5 /
  2026 追走ボート: v6 / 2026 機体搭載「陽還」: v6β）。**2025 年大会優勝。**
* **本ブランチ（`PONSv7.1`）は 2027・2028 年大会向け v7.1 基板専用です。**  
  姿勢センサーを Murata SCH16T-K01（外付け FPC）とし、電源回路の安全対策（Q3/Q4/F1/U10）を施した最新設計です。  
  BNO085 搭載の初代 v7 基板用は [`PONSv7`](https://github.com/MasaoC/GPS-TFT-Map_PONS/tree/PONSv7) ブランチを参照してください。
* **v3〜v6 ブランチが実際にフライト利用した実績のある安定版です。** v7 / v7.1 はまだ大会で使っていません。

---

## PONS を導入するメリット

**飛んでいる間の「道具」であり、飛んだあとの「計測器」でもあります。** 当日の誘導と、次期機体の設計の両方に活用できます。

### 鳥人間コンテストに特化している点
* **パイロット中心設計**: 直射日光下（1000ニト高輝度 TFT）や騒音・ペダリング負荷のなかでも、画面を注視せず音声警報だけでコースやバンク角を把握可能。
* **Auto 10km 自動誘導**: プラットホーム離脱から 10km 折り返し、帰還までを距離判定で自動認識・案内（→ [大会本番での使い方](#大会本番での使い方auto-10km-モード)）。
* **機上風向・風速推定**: 対気速度センサー不要で、ピッチ角と対地速度から機上で風向・風速ベクトルをリアルタイム推定（→ [風の推定](#風の推定)）。
* **PONS Link（機体⇄ボート テレメトリ）**: 920MHz 帯 LoRa により、ボート側の受信機へ機体の航法画面・風情報・警報音をリアルタイムで完全ミラーリング（→ [PONS Link](#pons-link機体ボート-テレメトリ無線)）。

### 次期機体の設計へのフィードバック
SD カードのログを付属ツール（`tools/`）で解析し、機体特性の定量評価が可能です。
* **縦の癖**: フゴイド周期の同定、対気速度の分散推定、巡航余裕度の確認。
* **横の癖**: 上反角・ラダー効果に起因するロール／ヨーの固有周期分析。
* **構造荷重の検証**: 巡航中の鉛直加速度（実測最大 +0.18 / −0.25 G、荷重倍数 1.17 / 0.77）から主桁設計荷重を裏付け。

---

## ドキュメント一覧

| ドキュメント | 対象・内容 |
|---|---|
| **[PONS_HPA v7.1 説明書](https://docs.google.com/document/d/1KvTG9RTmQfcqMZj5Lb0X9cOWW-vuLJjpPzH3PTkBcsk/)** | **パイロット・ボートマン向け**。操作手順、画面の見方、警告音の意味、大会当日の運用手順（Google Docs） |
| **この README** | **開発者・自作者向け**。アーキテクチャ、設計根拠、ハードウェア構成、SD 構成、解析ツール |
| **[ハードウェア製作・調達ガイド](docs/hardware.md)** | JLCPCB PCBA 発注、手実装部品 BOM、代替部品検証、組み立て・導通チェック手順 |
| **[IMU SCH16T 統合仕様](docs/imu_sch16t_plan.md)** | Murata SCH16T-K01 SPI 通信仕様、アーキテクチャ抽象化、ESKF / バリオ KF 統合仕様 |
| **[IMU SCH16T 立ち上げ](docs/imu_sch16t_bringup.md)** | SCH16T の結線・SPI1 単独テストと導通確認手順 |
| **[無線 PONS Link 仕様](docs/pons_link.md)** | 920MHz LoRa テレメトリ、32 バイト固定フレーム形式 2、電波法適合、運用ルール、実測性能 |
| **[無線立ち上げ試験](docs/pons_link_bringup.md)** | 基板到着後の PONS Link 立ち上げ・動作確認手順 |
| **[音仕様](docs/pons_sound.md)** | 音声 3 系統（WAV / トーン / バリオ）、同時再生・排他制御、WAV 一覧・差し替え手順 |
| **[電源・安全保護回路仕様](docs/pons_power.md)** | 充電 IC 焼損防止対策、SW OFF 充電検出、過放電ラッチ・充電禁止ロック、待機中自動減光 |
| **[充電残量・時間推計仕様](docs/pons_charge_estimation.md)** | 充電中の開放電圧・残量(%)・満充電残り時間の推計物理モデル |
| **[ナビゲーション仕様](docs/pons_navigation.md)** | 方位・距離計算ロジック、Auto 10km モード、コース警報アルゴリズム |

---

## スペック (v7.1)

| 項目 | 仕様 |
|---|---|
| **外形寸法 / 重量** | W59 × H81 × D20 mm / 約 62g（ケース込） |
| **ディスプレイ** | 2.8 インチ **1000 ニト** 高輝度 TFT（Newhaven NHD-2.8-240320AF-CSXP-F）。自動調光対応 |
| **GNSS** | u-blox SAM-M10Q（2Hz、位置精度 1.5m、AssistNow Autonomous 対応、ファーム ROM SPG 5.10） |
| **気圧センサー** | MS5611（約 40Hz 計測・約 4Hz でバリオ KF へ融合、2Hz SD 記録） |
| **モーションセンサー** | Murata **SCH16T-K01-10**（外付けフレキ、SPI1 250Hz ポーリング） |
| **姿勢推定** | **機上 250Hz ESKF**（GNSS 航跡ヨー注入 ＋ 2Hz 重力観測レベリング） |
| **昇降計（バリオ）** | **KF 融合**（SCH16T 鉛直加速度 ＋ MS5611 気圧高度。デッドバンド ±0.25m/s） |
| **無線 (PONS Link)** | 920MHz LoRa（E220-900T22S(JP)、技適取得済・免許不要、送信 13dBm / 到達実測 **350m**） |
| **バッテリー / 電源** | LiPo 860mAh、USB-C 充電（303mA）。電源スイッチ後段ロードスイッチ Q3、逆接保護 Q4、過電圧保護 U10 |
| **稼働時間** | 輝度 High で約 3 時間。Low（自動調光・待機減光有効）で大幅に延長 |
| **ストレージ** | 内蔵 16MB FLASH（W25Q128：ベクタ地図・音声 40 ファイル・起動ロゴ）、microSD（ログ記録） |

---

## 設計と根拠

### 1. 姿勢推定（ESKF: 誤差状態カルマンフィルター）
内蔵フュージョンチップ（BNO085 等）は協調旋回時に比力横成分がゼロになるためロール角を過小評価し、地磁気方位も機体電子機器の影響で 30° 以上狂う課題がありました。  
本システムでは **生のジャイロ・加速度（SCH16T）** と **GNSS 航跡・対地速度** をカルマンフィルター（ESKF）で機上融合しています。
* **初期水平化**: 静止 2 秒間の平均比力から初期ロール・ピッチを決定。
* **初期ヨー注入**: 発進滑走時（対地速度 > 3.0m/s）の最初の航跡（True Track）から真方位を注入（接地中は横滑り角が原理的にゼロのため、航跡＝機首方位）。
* **重力観測（レベリング）**: 準定常直進時（旋回レート小、$\|a\| \approx 1g$）に比力水平成分を 2Hz で観測更新し、GNSS 途絶時でもロール・ピッチの長期ドリフトを防止（実機走行試験で誤差中央値 21.3° → 1.3° に抑制）。

### 2. 風の推定と推定 TAS
定常飛行時の揚力平衡式 $L = W = \frac{1}{2}\rho V^2 S C_L$ および揚力傾斜の線形性から、ピッチ角 $\theta$ [deg] から対気速度 $V$ [m/s] を算出します。

$$V(\theta) = V_0 \sqrt{\frac{K}{K + \theta}}$$

* **係数は機体・重量・重心で変わるため、SD カードの `settings.txt` で設定可能**:
  | キー | 意味 | 既定値 | 設定範囲 |
  |---|---|---|---|
  | `airspeed_v0` | $V_0$: ピッチ 0 度での巡航対気速度 [m/s] | 7.00 | 3〜20 |
  | `airspeed_k` | $K$: θ=0 の姿勢から揚力ゼロの姿勢までの角度（取付角 − 零揚力角）[度] | 10.00 | 3〜60 |
  | `airspeed_min` | 推定対気速度の下限 [m/s] | 5.80 | 1〜20 |
  | `airspeed_max` | 推定対気速度の上限 [m/s] | 9.00 | 1〜25 |

  `airspeed_min` ≥ `airspeed_max` のときは両方を既定（5.80〜9.00）に戻して log.txt の `ERR airspeed_min ...` に残す。
* ピッチには**過去 10 秒の移動平均**（平均ピッチ `Pavg`）を使う（2026-11-07 までは時定数 10 秒の一次遅れだった）。
* $\text{風ベクトル} = \text{対地速度ベクトル} - \text{対気速度ベクトル}$（対気速度の向き＝機首方位）により算出。
* 同じ式の値を**推定 TAS** としてヘッダー右の大きい枠にも出せる（IMU/ESKF 画面 1 ページ目の `Header: Pavg / TAS`。`settings.txt` の `header_tas:1`）。
  青い箱に白字・縦書きの `TAS`。地上は数字に白い横線と `GROUND` の札が入る。対地速度 3m/s 以上で札がすぐ消え、それが 10 秒続くと線も取れる。上下限に張り付いたら灰色の箱。
  較正のやり直しが要るときは赤い線と `CALIBRATE`、GNSS の速度が来ていないときは橙の線と `NO GNSS` の札、GNSS は来ているが向きがまだ決まっていない（止まっている間。3m/s 以上で動けば決まる）ときは黄色の線と `YAW ALIGN` の札（平均ピッチの箱も同じ）。
  平均ピッチは地図の上端（`TAS` の小箱の左）に小さく残る。TAS にすると日本語の案内（画像と曲線の 2 画面・音声）が出る。
  仕組みと精度は **[docs/pons_tas.md](docs/pons_tas.md)**（増減は信用できるが、値は取り付け 1° で約 0.4m/s ずれる）。
* 旋回中の横滑り角による誤差混入を防ぐため、直進が累計 10 秒以上継続した場合のみ更新。
* `settings.txt` は本体が保存のたびに書き直します（書き込んだコメント行は消えるため、メモは別ファイルに残してください）。
  書き直しは `settings.tmp` に書き切ってから入れ替えます（途中で電源が切れても設定が消えない。2026-11-14〜）。`settings.tmp` が残っていたら、次の起動で `settings.txt` に戻して読みます。

### 3. GNSS の起動を速くする（AssistNow Autonomous）
GNSS の時計と受信した軌道データ（エフェメリス）をバックアップ電池（BT1、MS621FE）で保つので、最後に受信してから約 4 時間以内なら
**起動から数秒で測位** します（ホットスタート）。それより後でも、SAM-M10Q が自律予測した数日先までの衛星軌道（AssistNow Autonomous。ANA）を
BT1 で保つので、約 3 日以内なら速く測位します（データシートは 2 日前のデータで 4 秒。通常のコールドスタートは 23 秒〜、小さいアンテナや悪い空では数分）。

**BT1 が切れていた起動（コールドスタート）だけは、その起動の間 ANA を切ります**（2026-11-13〜）。この GNSS のファーム（ROM SPG 5.10。`log.txt` の `GNSS VER:`）は、
コールドスタートのあと ANA が有効だと QZSS を航法に使わないためです（SPG 5.30 のリリースノートの既知の制限。5.30 で直ったが、SAM-M10Q は外付けフラッシュが無いので上げられない）。
BT1 の生死は最初の NAV-PVT で分かるので、ANA の設定はそのあとに送ります。`log.txt` の `GNSS ANA on|off for this boot (...): ack` が結果、
`GNSS QZSS first used 52.0s after boot (...)` と 10 分ごとの `GNSS SVS used G8 E5 B6 Q2 R0 (QZSS seen 3) ana=off(cold)` で QZSS を使っているかが分かります（まだ実機で確かめていない）。

**起動時に GNSS の衛星系の設定（CFG-SIGNAL）を読み、QZSS が切られていれば入れ、BeiDou を B1I にします**（2026-11-13〜、B1I は 2026-11-14〜、実機未確認）。
SAM-M10Q（SPG 5.10）の工場出荷は BeiDou を B1C で受けますが、日本の上空に多い BeiDou の静止・傾斜軌道の衛星は B1I しか出しておらず、
2026-11-13〜14 の記録では B1C の BeiDou を一度も使えていませんでした。M10 は B1I を B1C とも GLONASS とも同時に有効にできないので、
**B1I にすると GLONASS は使わなくなります**（`settings.h` の `GNSS_BDS_B1I`。0 にすると工場出荷のまま）。
2026-11-13 の `log.txt` で、ANA が有効な普段の起動では屋外（車の中）でも QZSS がほとんど受かっておらず（`QZSS seen` 0〜1）、BeiDou も使っていなかったためです（読んでみると設定は工場出荷のまま全部有効だった）。
書くのは RAM だけで（電源を切れば戻り、起動のたびに書き直す）、入れ直すと GNSS が測位をやり直すので、ANA の設定・航法データベースの戻し・
外からの時刻入れはそのあとにします。`log.txt` には `GNSS SIGNAL ram: GPS=1 SBAS=1 GAL=1 BDS=0 QZSS=0 GLO=1 | L1CA=1 ...`
（いま効いている値）、書き直したときは `GNSS SIGNAL set (RAM): GLO=0 B1I=1 B1C=0: ack` と読み直した `GNSS SIGNAL ram(after enable): ...`、
続いて `GNSS SIGNAL bbr: ...`（BT1 で残る値。書かれていなければ `NAK`）と `GNSS SIGNAL default: ...`（工場出荷）が出ます。

バックアップ電池が切れた起動に備えて、通電中に GNSS の航法データベース（UBX-MGA-DBD）を SD の `gnss_dbd.bin` へ写しておき、
起動時に時計が死んでいたときだけ GNSS へ戻します（2026-11-09〜、まだ実機で確かめていない。`gnss_dbd.cpp`）。
はっきり効くのは前回の保存から約 4 時間以内（エフェメリスの寿命。データベースには ANA の予測も入っているが、上のとおりコールドの起動では ANA を切るので使わない）。
それより古いとアルマナック（どの衛星を探すか）だけになります。
保存は止まっているときだけ（飛行中はしない）。
`log.txt` の `GNSS FIXED ... after boot rtc=lost dbd=40/52 resend=52/52 time=14.2s` で、戻した結果と測位までの秒数がわかります。
吸い出し・戻しの 1 回ごとに `GNSS DBD IO (...)` の行で通信の様子（位置の更新が待たされた最大・受信 FIFO のたまり・バイトの欠け・返事の遅れ）を残します。
**PC につないでいれば、PC の時刻も GNSS へ入れます**（2026-11-10〜、まだ実機で確かめていない）。Flight Viewer が接続のたびに
`PONS:TIME,<UNIX 時刻 ms>` を送り、GNSS が時刻を知らない（BT1 が切れていた）ときだけ本体が GNSS へ入れます。戻したデータベースが
「時刻が無いので使えない」と断られずに済みます。結果は `log.txt` の `GNSS TIME (pc): ...`（PC の時計のずれも最初の fix で残す）。
**LoRa で仲間からも時刻をもらいます**（2026-11-13〜、まだ実機で確かめていない）。ボートは機体のテレメトリから、機体はボートの時刻のビーコンから。fix の前でも、
GNSS の時計（BT1 の RTC）の時刻をその精度（NAV-PVT の tAcc）つきで渡します（精度が 4 秒より悪ければ使いません）。同じ口（`gnss_dbd_give_time()`）に渡します（下の 4. と [docs/pons_link.md](docs/pons_link.md) §4.4）。
机の上では USB シリアルの `PONS:DBD,COLD`（コールドにして戻す）/ `COLDONLY` / `HOT` / `SAVE` / `STATUS` と、
`COLD,TIME` / `COLDONLY,TIME`（リセット前に本体が覚えた時刻を、PC の時刻の代わりに入れる）で試せます
（`COLD` / `COLDONLY` / `HOT` を打つと、再起動するまで自動の吸い出しは止まります。`SAVE` は効きます）。
`COLD` / `COLDONLY` は、本物のコールドの起動と同じく、その起動の間 ANA を切ってからリセットします（2026-11-14〜。`GNSS ANA off for this boot (cold-start test ...)`）。
GNSS DETAIL 3 の下の 2 行（2026-11-14〜）は GNSS の受け方です: `RF jam:12 50+:3/60 noise:91 agc:4464`（`50+` は直近 60 秒で妨害の指標 jamInd が 50 以上だった秒数。
6 以上で橙、18 以上で赤）と `C/N0 top4:30.8 mean:24.7 trk:14`（受信の強さと追尾している衛星の数）。log.txt の `grf` 行と同じ物差しです。
計画と根拠は [docs/pons_ttff_assist_plan.md](docs/pons_ttff_assist_plan.md) §3（時刻は §3.6）。

### 4. PONS Link（機体⇄ボート テレメトリ無線）
* 送信機（機体）から受信機（ボート）へ、**32 バイト固定フレーム**（印 `0xA4`。2026-11-07〜）を送信（テレメトリは下り一方向）。
  グループは A〜D（`settings.txt` の `link_group:B`）。推定 TAS と平均ピッチは毎回、風は 4 秒に 1 回。
* 電波法適合のため、標準ではローワーバンド（CH0/3/6/9/12、SF8、1Hz）を使用し、混雑時はアッパーバンド（CH15/21/27）へ退避可能。
* **GNSS の時刻の助け合い**（2026-11-13〜、実機未確認）: BT1 が切れて GNSS が時刻を知らない機体・ボートへ、時刻を持つ仲間が精度つきで時刻を渡す
  （印 `0x58` の 32 バイトのビーコン）。機体は時刻をもらう間だけ送信の合間も受信し、受信機の WIRELESS 画面に ` TIME?` と出ます。
  機体が上りで変えるのは「GNSS へ時刻を 1 回入れる」ことだけです。`settings.txt` の `link_assist:OFF` で止められます（既定 ON）。
* 詳細は **[docs/pons_link.md](docs/pons_link.md)** を参照してください。

---

## 画面仕様と操作

### 画面各部の構成
* **画面上部**: 対地速度 (m/s)、10秒平均ピッチ（`Pavg`。大きい枠。設定で推定 TAS にもできる）、真方位（`TT`）、速度精度（`sAcc`）。
  対地速度と真方位は、GNSS が断線した・fix していない・衛星 0 のとき赤い横線で消し、`NO GNSS` の札を載せる（読まない値。受信モードでは送信機の断線と fix で判断）。
* **画面中央**: 内蔵ベクタ地図（OSM 由来）、現在位置、航跡（緑線、最大 500 点 / 約 25km。跳躍 300m 以上は線引き除外）、パイロン基準線、コース警報アーク（向かうべき方位への赤線円弧）、旋回指示矢印（コースズレ 15° 以上で点滅）。
* **画面左下**: 風向風速ベクトル矢印（吹いていく方向、色は風速）、風向 3 桁（吹いてくる真方位）、ヨー精度（`Y95`）、瞬時ピッチ（`P`）、ロール（`R`）、自動ロールトリム（`Rtrim`）。
* **画面下部**: JST 時刻、最大対地速度（MAX GS。2 回連続の小さい方のみ採用）、目的地コース（TC）、目的地直線距離（km）、捕捉衛星数（10 以上で緑、9 以下は橙、4 以下は赤地。0 個は赤地に白字と白地に赤字を交互に点滅。分からないとき（受信を始めた直後・列の無いリプレイ）は灰色の `--sats`）、バッテリー残量（充電中 `CHG`、SW OFF 充電 `SW OFF`、無線ミラー中 `s72r85`）。
* **画面最下部**: ナビゲーションモード（`10K AWAY` / `10K INTO` / `FLY INTO` / `FLY AWAY`）、目的地名、SD 認識状態。

### 設定画面
NAV 画面でスイッチ長押しで入ります。
* 各行の右端のマークが設定状態を示します：**緑の丸＝本番推奨**、**赤の ×＝本番不可（デモやリプレイ等）**、**オレンジの三角＝許容だが既定外**（グレーのハイフンは対象外・OFF）。フッターの電池のマークは充電中が青の丸。**本番フライト前に赤の × が無いことを確認してください**。
* 地図拡大率は NAV 画面でボタンの**ダブルクリック**でも変更可能（標準縮尺 scaleindex=3 / 画面幅約 18km で緑）。
  * **受信モードでは送信機の縮尺に合わせません**（2026-11-12〜。ボートでは機体と違う縮尺で見られます）。
    `Map scale` の行の後ろに送信機の縮尺を `(S: 18km)` と添え、送信機が標準縮尺なら緑・違えば赤・まだ届いていなければ灰の `(S: --)` で出します。受信機自身の行の右端はハイフン（判定しない）です。
* 設定は SD の `settings.txt` に自動保存されますが、**DEMO / REPLAY モードは保存されません**（再起動すれば必ず本番航法へ復帰する安全設計）。
* **`REPLAY/DEMO`** の行から入る画面で、リプレイするファイルとデモの地点（BIWAKO / SHIRAHAMA / KASAOKA / FUJIGAWA / TOKYO / OSAKA）をまとめて選びます。短押しでカーソル移動、長押しで決定（その場で始めて地図画面へ）。先頭の `OFF (Normal GNSS)` でリプレイもデモも止まります。デモとリプレイは同時には使えず、どちらかを始めるともう片方は止まります。
* `Save & Exit >>` は他の行と見分けやすいよう中央に寄せてあります。
* 設定画面を 3 分操作しないと地図へ戻ります。設定画面を含め、**地図以外の画面（IMU/ESKF・GNSS 詳細・VARIO・WIRELESS など）を出したまま動き出すと**（自機の対地速度 3m/s 以上が 5 秒）、地図へ戻ります（降下する 2 音）。受信モードと PC 接続の画面は対象外です。
* **本番前チェック（画面右上）**:
  飛ぶ前に確かめる項目が揃うと緑の `READY` となり、地上静止中に 1 度だけ「準備完了」と音声読み上げします。欠けていると赤の `NOT READY` と不足項目が表示されます。
  
  | 表示 | 足りない項目 |
  |---|---|
  | `GNSS` | 3D 測位、`gnssFixOK`、水平位置精度 5m 以内 |
  | `IMU` | SCH16T が見つからない・応答していない（v7.1 は SCH16T を必ずつなぐ。設定画面の IMU の行も赤の ×） |
  | `ESKF` | 姿勢推定が未収束 |
  | `CALIB` | 較正のやり直しが必要（マウントから外された） |
  | `ATT` | 地上で姿勢が申告値からズレ続けている（地上チェック発報中） |
  | `SET` | 設定画面に赤の × がある（標準縮尺でない、Auto 10km でない等） |
  | `USB` | USB ケーブルが挿さっている |
  | `BATT` | 電池残量 50% 未満、過放電ラッチ中、または電源異常 |
  | `SD` | SD カードが認識できない |
  | `LINK` | 送信モードで無線モジュール無応答、または重複送信機あり |
* **フッター（画面下 3 行）**: 電池（または充電の残り時間）、CPU・気圧センサーの温度、照度センサーと画面の明るさ。
  3 行目は `VEML 123lx  BL 35% AUTO` の形で、照度・いまの点灯率・その決まりを示します（右端のマークは照度センサーが応答していれば緑の丸、無ければ赤の ×）。
  起動画面の後半ページ（無線の結果）の右下にも `VEML:OK 123lx` / `VEML:NG` が出ます。

### 画面の明るさ（バックライト）
輝度スイッチと照度センサー（VEML7700、ケースカバー基板）で決まります。設定画面のフッターの名前で示します。

| 表示 | 条件 | 点灯率 |
|---|---|---|
| `SW BRIGHT` | 輝度スイッチ High | 常に 100%（待機中の減光もしない） |
| `AUTO` | 輝度スイッチ Low・照度センサーあり | 照度の対数で比例。曲線は設定画面の `AUTO Brightness` で選ぶ（下の表）。時定数 2 秒でゆっくり追う |
| `LAST LUX` | 照度センサーが途中で読めなくなった | 最後に読めた照度のまま（昼間に急に暗くしない） |
| `NO SENSOR` | 照度センサーが一度も読めていない | 5% 固定（待機中の減光に入っても表示はこのまま） |
| `IDLE DIM` | 待機中の自動減光（照度センサーがあるとき） | 5%（暗い所では `AUTO` の値を超えない） |

* **`AUTO Brightness`（設定画面。`settings.txt` の `auto_brightness:ECO` / `BRIGHT`、既定は ECO）**:

  | 照度（センサーの読み） | 10 lx | 100 lx | 1000 lx | 20000 lx | 50000 lx 以上 |
  |---|---|---|---|---|---|
  | `Eco` | 19% | 34% | 50% | 70% | 100% |
  | `Bright` | 35% | 68% | 100% | 100% | 100% |

  どちらも 1 lx 以下は 3%。Eco は曇りの昼間（約 20000 lx）を 70% で読めることを基準にしてあります。
  lx は窓越しのセンサーの読みなので照度計とは合いません。合わせるときはフッターの `VEML` の値を見てください（1 万 lx 以上は `21klx` のように k で出ます）。
  照度センサーは約 2900 lx を超えると感度を 1/32 に切り替え、約 12 万 lx まで測ります（1500 lx を下回ると戻す）。
* **待機中の自動減光**: 対地速度 0.3 m/s 未満・IMU が静止・照度が急に下がっていない、の 3 つが 30 秒続くと減光します。ボタン・輝度スイッチ High・対地速度 0.6 m/s 以上・IMU の動き・照度で見た手の動きで即座に戻り、戻ってから最低 30 秒は減光しません。手の動きは次のどちらかです（変化量 5 lx 以上のときだけ）。
  * かざす: 直近 1 秒の最大から 50% 以上下がった。
  * あおぐ: 直近 1 秒の最大から 30% 以上下がり、そこから 1 秒以内に、いちばん暗い読みから 30% 以上明るくなった。

  照度は上限なしで、50 ms ごとに読んで比べます。20000 lx を超える晴れの日でも、手の影がセンサーにかかれば戻ります。雲の縁は数秒かけて暗くなったままなので、まず反応しません。1〜2 秒で通り過ぎる雲の切れ端では戻ることがありますが、30 秒明るくなるだけです。USB 給電中・リプレイ／デモ／無線ミラー中・電源の警告中は減光しません。
* **電池低下**: 3.5V 以下で 4 秒点灯・4 秒消灯、3.0V 以下で 2 秒点灯・10 秒消灯をくり返します（点灯中はいつもの明るさ。フッターに `SAVER` / `SAVER2`）。
* 値は `settings.h` の `TFT_BL_*` / `BL_AUTO_*` / `BL_ECO_*` / `BL_DIM_*`、動きは `backlight.cpp`。

### IMU / ESKF 画面（点検と較正）
2 ページ構成（短押し＝カーソル移動、長押し＝実行）。操作する項目はすべて 1 ページ目にあります。
* **1 ページ目（点検手順）**:
  1. `SET PITCH`: 機体の現在ピッチ申告値（-3.5〜+2.0°、0.5° 刻み）。本番プラットホーム（-3.5°）でも申告値に合わせれば正確に水平較正可能。
  2. `SET ROLL`: ロール申告値（通常 0°。ウィングロー保持時のみ使用）。
  3. `APPLY`: ゼロ点較正の実行。ボタンを離してから 1 秒後に実行（ボタン押下による機体揺れを回避）。
  4. `Roll/Pitch/Yaw func`: 姿勢機能の一括 ON/OFF マスタースイッチ。
  5. `Roll trim during flight`: 直進中のロール自動トリムの ON/OFF。
  6. `Wind estimate`: 風推定の ON/OFF。
* **2 ページ目（見るだけ）**: 上に生ジャイロ・加速度と静止判定、下に ESKF 内部診断・ヨー精度・`level offset`（前回 APPLY 日時）。行は `< Back to page 1` と `Exit >>`（地図画面へ）だけ。
* 右上のマークと、設定画面の `IMU / ESKF detail` 行のマークは同じ判定です（ESKF 収束・姿勢機能 ON・自動ロールトリム ON・トリム累積が小さいで緑の丸、要 APPLY で赤の ×）。ESKF が収束するまでは設定画面の行もオレンジの三角です。

---

## 警告音・警報

詳細は **[音仕様 (docs/pons_sound.md)](docs/pons_sound.md)** を参照してください。

* **航路・コース警報**: 15° 以上の針路変化で Chime＋「トラック」、向かうべき方位（TC）からのズレ放置で 4Chime＋「進路、右(左)に旋回」（修正中は停止）。
* **バンク角警告**: ロール絶対値が 4° を 1 秒超えると「バンク！バンク！」音声。
* **待機中姿勢ズレ / 較正警告**: 地上静止中に申告値から 3° ズレが 60 秒継続で警告。日付を跨いだ場合は再較正を促す音声。
* **電源・安全警報**: 電池電圧 3.5V 未満で「バッテリー低下」＋バックライト点滅省電力。過放電（3.0V 未満）ラッチ時は次回 USB 接続時に完全充電禁止ロック。高温充電（45°C 超）時は抜去警告。

---

## 大会本番での使い方（Auto 10km モード）

1. 目的地を **PLATHOME**、Navigation Mode を **Auto 10km** に設定。
2. プラットホーム上で右上が緑の `READY` となり、「準備完了」が鳴ることを確認。
3. 発進時は自動で `10K AWAY`（往路）となり、プラットホームから離れる最短距離方角へ誘導。
4. プラットホームから 10.475km 離脱すると自動更新音が鳴り `10K INTO`（復路）へ自動反転。目視でパイロン旋回を終えるまではコース警報を無視し、旋回完了後に誘導線へ合流。
5. 復路でプラットホームから 1.5km 以内に入ると再び `10K AWAY` に切り替わり、1km パイロン探索を支援。
* 折り返し状態は SD に保存されるため、飛行中に電源再起動が発生しても直前のモードに正確に復帰します。

---

## ハードウェア構成と自作ガイド

### 発注受付
個人事業主として受注・製作を受け付けています。
* **フル機能**（GNSS ナビ・バリオ・無線・姿勢推定すべて）：1 個 4 万円（SD カード・ケース込）
* **GNSS ナビ機能のみ**（バリオ・無線・姿勢推定なし）：1 個 2 万円（製造・材料費が安くなるため）
* 2 個以上ご注文の場合は相応に割引します。
* 価格・納期・送料は個別にご案内します。見積もりをご希望の方は masaochiguchi@gmail.com までお問い合わせください。
* 納品前に全数動作確認を行います。

### 使用部品 (v7.1)
* **マイコン**: RP2350B (QFN-80) ＋ 外付け FLASH 16MB（W25Q128）
* **センサー**: SAM-M10Q（GNSS）、MS5611（気圧）、Murata SCH16T-K01-10（外付けフレキ IMU、SPI1）、VEML7700（照度）
* **無線**: E220-900T22S(JP) ＋ TX915-FPC-4510 アンテナ（920MHz LoRa）
* **ディスプレイ / 電源**: 2.8 インチ 1000 ニト TFT、DTP603048(PHR) 860mAh、MCP73831 充電 IC

> 発注用 BOM・JLCPCB 発注手順・手実装手順の完全なガイドは **[docs/hardware.md](docs/hardware.md)** を参照してください。

---

## ソフトウェアのビルド

* 環境: Arduino IDE ＋ arduino-pico コア
* 対象ボード: **Generic RP2350** / Flash: **16MB (no FS)**
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
## KiCad design kicad/mainboard/DisplayModule_PONSv71.kicad_pcb

Parts:
C1: 22u; C_0603_1608Metric; LCSC C59461
C2, C3, C6, C13, C49, C50, C51: 1u; C_0402_1005Metric_small_pads; LCSC C52923
C4, C15, C33, C35: 100n; C_0402_1005Metric_small_pads; LCSC C1525
C7, C14: 47u; C_0805_2012Metric; LCSC C16780
C8, C10: 220p; C_0402_1005Metric_small_pads; LCSC C1530
C9: 100u; C_1206_3216Metric; LCSC C15008
C11, C39, C41: 10u; C_0402_1005Metric_small_pads; LCSC C15525
C32: 10u; C_0805_2012Metric; LCSC C15850
C37, C40: 4.7u 16V; C_0603_1608Metric; LCSC C19666
D1: VBUS_LED_W; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2290
D2, D4: LED_R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286
D3: 1N5819WS; D_SOD-323; LCSC C191023
D6, D7: LED_R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286; not fitted
D8: VBUS_LED_W; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2290; not fitted
F1: 0805L050; Fuse_0805_2012Metric; LCSC C207022
FB1, FB2: 600; L_0805_2012Metric; LCSC C1017
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: Ext. Speaker; PinHeader_1x02_P2.54mm_Vertical
J2: 54132-4062; MOLEX_54132-4062; PARTREV G; LCSC C505102
J3: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5; LCSC C114218
J9: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
L2: 1.5u; L_APV_ANR3015; LCSC C701165
PWR1: 1s Lipo Power input; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal; LCSC C173752
Q1, Q2, Q3, Q4: AO3401A; SOT-23; LCSC C15127
R1, R4: 1k; R_0402_1005Metric; LCSC C11702
R2, R34, R37: 10k; R_0402_1005Metric; LCSC C25744
R3: 470; R_0402_1005Metric; LCSC C25117
R5, R6, R11: 100; R_0402_1005Metric; LCSC C25076
R7, R38, R47: 100k; R_0402_1005Metric; LCSC C25741
R8, R40: 200; R_0402_1005Metric; LCSC C25087
R10: 1; R_0603_1608Metric; LCSC C22936
R12, R13, R14, R15, R16, R17: 33; R_0402_1005Metric; LCSC C25105
R18, R19, R20, R21, R22: 4.7k; R_0402_1005Metric; LCSC C25900
R35, R45, R46: 5.1k; R_0402_1005Metric; LCSC C25905
R39: 3.3k; R_0402_1005Metric; LCSC C25890
SW4: MST-12D18G2 SMD SLIDE SWITCH; SW-SMD_3P-L9.1-W3.5-P2.50_MST-12D18G2; MPN MST-12D18G2 SMD Slide Switch; LCSC C49023765
U1: PAM8302AASCR; MSOP-8_3x3mm_P0.65mm; LCSC C113367
U4: TPS63031DSK; WSON-10-1EP_2.5x2.5mm_P0.5mm_EP1.2x2mm; LCSC C15516
U5: MCP73831-2-OT; SOT-23-5; LCSC C424093
U10, U11: NCP360SNT1G; TSOP-5_1.65x3.05mm_P0.95mm; LCSC C603707

Connections:
+3V3: C6.1, C7.1, C9.1, C11.1, C13.1, C14.1, C15.1, C39.1, C41.1, J2.28, J2.33, J2.34, J3.4 (VDD), Q1.2 (S), R18.2, R19.2, R20.2, R21.2, R22.2, R47.1, U1.6 (VDD), U4.1 (VOUT), U4.10 (FB); also elsewhere on the board
/GATE_Q3Q4: C33.2, Q3.1 (G), Q4.1 (G), R37.1, R38.2
/VBAT_THERMAL: C40.1, F1.1, U5.3 (V_{BAT})
ADC0: SW4.3; also elsewhere on the board
AMP_SD: R7.1, U1.1 (~SD); also elsewhere on the board
BATPWR: F1.2, Q2.3 (D), Q3.3 (D); also elsewhere on the board
DB0: J2.27; also elsewhere on the board
DB1: J2.26; also elsewhere on the board
DB2: J2.25; also elsewhere on the board
DB3: J2.24; also elsewhere on the board
DB4: J2.23; also elsewhere on the board
DB5: J2.22; also elsewhere on the board
DB6: J2.21; also elsewhere on the board
DB7: J2.20; also elsewhere on the board
DB8: J2.19; also elsewhere on the board
DB9: J2.18; also elsewhere on the board
DB10: J2.17; also elsewhere on the board
DB11: J2.16; also elsewhere on the board
DB12: J2.15; also elsewhere on the board
DB13: J2.14; also elsewhere on the board
DB14: J2.13; also elsewhere on the board
DB15: J2.12; also elsewhere on the board
GND: C3.1, C4.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C32.2, C35.2, C37.2, C39.2, C40.2, C41.2, C49.2, C50.1, C51.1, D1.1 (K), D2.1 (K), D7.1 (K), D8.1 (K), J2.2, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J2.31, J2.40, J3.6 (VSS), J3.9 (DET_B), J3.SH (SHIELD), J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J9.SH (SHIELD), PWR1.2, R2.1, R7.2, R35.2, R39.2, R45.2, R46.2, SW4.2, U1.7 (GND), U4.3 (PGND), U4.9 (GND), U4.11 (PGND), U5.2 (V_{SS}), U10.2 (GND), U10.3 (~EN); also elsewhere on the board
unnamed: C2.1, R1.1, R2.2
unnamed: C2.2, R5.1
unnamed: C3.2, R6.1
unnamed: C4.2, R1.2, R4.1
unnamed: D1.2 (A), D8.2 (A), R3.2
unnamed: D2.2 (A), D7.2 (A), R8.2
unnamed: C1.2, D4.2 (A), D6.2 (A), R40.2
unnamed: C1.1, D4.1 (K), D6.1 (K), U5.1 (STAT)
unnamed: C8.1, FB2.2, J1.1
unnamed: C10.1, FB1.2, J1.2
unnamed: J2.3, R10.2
unnamed: J3.5 (CLK), R15.2
unnamed: J3.3 (CMD), R14.2, R20.1
unnamed: J3.7 (DAT0), R16.2, R21.1
unnamed: J3.8 (DAT1), R17.2, R22.1
unnamed: J3.1 (DAT2), R12.2, R18.1
unnamed: J3.2 (DAT3/CD), R13.2, R19.1
unnamed: J9.A5 (CC1), R45.1
unnamed: J9.B5 (CC2), R46.1
unnamed: Q1.3 (D), R10.1
unnamed: Q1.1 (G), R11.1, R47.2
unnamed: C33.1, Q3.2 (S), Q4.2 (S), R38.1
unnamed: R5.2, U1.3 (IN+)
unnamed: R6.2, U1.4 (IN-)
unnamed: FB1.1, U1.5 (OUT+)
unnamed: FB2.1, U1.8 (OUT-)
unnamed: C35.1, U4.6 (EN), U4.7 (PS/SYNC), U4.8 (VINA)
unnamed: L2.1, U4.4 (L1)
unnamed: L2.2, U4.2 (L2)
unnamed: R39.1, U5.5 (PROG)
unnamed: C51.2, J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), U10.1 (IN)
PWM_AUDIO: R4.2; also elsewhere on the board
PWR_GATE_SW: R37.2, SW4.1
SD_CLK: R15.1; also elsewhere on the board
SD_CMD: R14.1; also elsewhere on the board
SD_DAT0: R16.1; also elsewhere on the board
SD_DAT1: R17.1; also elsewhere on the board
SD_DAT2: R12.1; also elsewhere on the board
SD_DAT3: R13.1; also elsewhere on the board
SD_DETA: J3.10 (DET_A); also elsewhere on the board
TFT_DC: J2.30; also elsewhere on the board
TFT_MOSFET_G: R11.2; also elsewhere on the board
TFT_RESET: J2.11; also elsewhere on the board
TFT_WR: J2.29; also elsewhere on the board
USB_D+: J9.A6 (D+), J9.B6 (D+); also elsewhere on the board
USB_D-: J9.A7 (D-), J9.B7 (D-); also elsewhere on the board
USB_SENS: C49.1, R34.2, R35.1; also elsewhere on the board
USR_LED: R8.1; also elsewhere on the board
VBAT_RAW: PWR1.1, Q4.3 (D)
VBUS_5V: C37.1, C50.2, D3.2 (A), Q2.1 (G), R3.1, R34.1, R40.1, U5.4 (V_{DD}), U10.5 (OUT)
VSYS: C32.1, D3.1 (K), Q2.2 (S), U4.5 (VIN)

Notes on the sheet:
(5V-3.0V)/470 Ohm =4.2mA
USB surge protection.
Q4: 電池の逆接保護（D が電池側） USB を挿したままの逆接は守れない
SDIO
V7.1 初期版は Q4 G は、抵抗GND
[Memo JLCPCB BOM Exemption] J1 Speaker socket (No parts required) J4 Debug SH 3p(No use. Debug purpose) U9 E220 LoRa (Due to 技適, 手実装) H1,H2,H3,H4 Hole
For parts handling...
(3.3V-2.0V)/200 Ohm=6.5mA
Recommend GC0351M-ND
Power
Q2: Bat Discharger For Battery Safety
(5V-2.0V)/200Ohm=15mA
SPEAKER
GZ2012D601TF
BAT IN
2.2k to limit current
Lipo Charger
(0.1uF+1kΩ Acceptable)
TFT NHD-2.8-240320AF-CSXP-F
Q3: ユーザー電源スイッチ
Grounding P-Ch FET Gate float at the same time
C1 Shuts off the LED when CHG ON/OFF alternating CHG due to leak current flow of BATPWR-R32(100kOhm)-SW-GND

Parts:
BT1: MS621FE; BatteryHolder_Seiko_MS621F
C42: 100u; C_1206_3216Metric; LCSC C15008
C43, C44, C46, C47, C48: 100n; C_0402_1005Metric_small_pads; LCSC C1525
C45: 10u; C_0402_1005Metric_small_pads; LCSC C15525
D5: RB751S40; D_SOD-523; LCSC C232576
J6: Conn_01x08_MountingPin; Molex_200528-0080_1x08-1MP_P1.00mm_Horizontal
J7: 2005280050; Molex_200528-0050_1x05-1MP_P1.00mm_Horizontal; MANUFACTURER_PART_NUMBER 2005280050
J8: 2005280040; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal; MANUFACTURER_PART_NUMBER 2005280040
R41, R42: 4.7k; R_0402_1005Metric; LCSC C25900
R43: 220; R_0402_1005Metric; LCSC C25091
R44: 470; R_0402_1005Metric; LCSC C25117
R49, R50, R51: 33; R_0402_1005Metric; LCSC C25105
TP1: TestPoint_2Pole; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U8: MS5611-01BA; LGA-8_3x5mm_P1.25mm; LCSC C15639
U9: E220-900T22S(JP)

Connections:
+3V3: C42.1, C43.1, C44.1, C45.1, C48.1, J6.8, J7.1, J8.1, R41.1, R42.1, R43.1, U8.1 (VDD), U8.2 (PS), U9.15 (VDD); also elsewhere on the board
GND: BT1.2 (-), C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, J6.1, J6.MP (MountPin), J7.2, J7.MP (MountPin), J8.4, J8.MP, U8.3 (GND), U8.4 (CSB), U8.5 (CSB), U9.1 (GND), U9.2 (GND), U9.3 (GND), U9.4 (GND), U9.11 (GND), U9.13 (GND), U9.19 (GND), U9.20 (GND), U9.22 (GND); also elsewhere on the board
I2C0_SCL: J8.2, R41.2, U8.8 (SCLK); also elsewhere on the board
I2C0_SDA: J8.3, R42.2, U8.7 (SDI/SDA); also elsewhere on the board
LORA_AUX: C46.1, U9.9 (AUX); also elsewhere on the board
LORA_M01: U9.5 (M0), U9.6 (M1); also elsewhere on the board
unnamed: BT1.1 (+), R44.2
unnamed: D5.2 (A), R43.2
unnamed: J6.4, R49.2
unnamed: J6.5, R50.2
unnamed: J6.6, R51.2
unnamed: TP1.2, U9.14 (SWCLK)
unnamed: TP1.1, U9.12 (SWDIO)
SCH16T_RESET: J6.7; also elsewhere on the board
SCH16T_SYNC: J6.3; also elsewhere on the board
SPI1_CS: R50.1; also elsewhere on the board
SPI1_RX_MISO: J6.2; also elsewhere on the board
SPI1_SCK: R49.1; also elsewhere on the board
SPI1_TX_MOSI: R51.1; also elsewhere on the board
UART0_RX: J7.3; also elsewhere on the board
UART0_TX: J7.4; also elsewhere on the board
UART1_RX: U9.8 (TXD); also elsewhere on the board
UART1_TX: U9.7 (RXD); also elsewhere on the board
V_BCKUP: C47.1, D5.1 (K), J7.5, R44.1

Notes on the sheet:
突入電流&バッテリー電流制限&最小 V_BCKP 対策
BT1が放電しきっていても、即座にGNSSが起動できる電圧をV_BCKUPに提供する V_BCKP Minimum operating voltage = 1.65V 抵抗によって、BT1バッテリーが空っぽでも、V_BCKUPに電圧が生じる((3.3-0.6)*470/690)=1.8Vぐらい 放電時の電圧降下はV=IR=10*10^-6*470 で、電圧降下はほとんどない P=IV=V^2/R=(0.5*10^-3)^2/500=0.5*10^-9=0.5nW
I2C address select
I2C(AMBIENT LIGHT SENSOR VEML7700)
LORA_TX
GNSS CONNECTOR Socket substitute:0522710479
LORA_RX
LORA
IMU
EXTERNAL CONNECTORS
MS5611

Parts:
C5: 100u; C_1206_3216Metric; LCSC C15008
C12, C20, C23, C25, C26, C27, C29, C30, C31, C34, C36, C38: 100n; C_0402_1005Metric_small_pads; LCSC C1525
C16, C19, C21, C22, C24: 4.7u; C_0402_1005Metric_small_pads; LCSC C23733
C17, C18: 33p; C_0402_1005Metric_small_pads; LCSC C1562
C28: 1u; C_0402_1005Metric_small_pads; LCSC C52923
J4: Conn_01x03_Shielded; JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical; LCSC C160389
L1: 3.3u; L_1008_2520Metric; LCSC C22416628
R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25804; not fitted
R23, R24, R27, R36: 1k; R_0402_1005Metric; LCSC C11702
R25: 33; R_0402_1005Metric; LCSC C25105
R26, R28: 100; R_0402_1005Metric; LCSC C25076
R29: 200; R_0402_1005Metric; LCSC C25087
R30, R31: 22; R_0402_1005Metric; LCSC C25092
R32: 100k; R_0402_1005Metric; LCSC C25741
R33: 51K; R_0402_1005Metric; LCSC C25794
R48: 4.7k; R_0402_1005Metric; LCSC C25900
SW1, SW2: SW_TS-1088; TS-1088-AR02016; LCSC C720477
SW3: PTS645VK392LFS; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS; LCSC C285519
SW5: MST-12D18G2 SMD SLIDE SWITCH; SW-SMD_3P-L9.1-W3.5-P2.50_MST-12D18G2; MPN MST-12D18G2 SMD Slide Switch; LCSC C49023765
U2: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm; LCSC C97521
U3: RP2350_80QFN; RP2350-QFN-80-1EP_10x10_P0.4mm_EP3.4x3.4mm_ThermalVias; LCSC C42415655
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9002

Connections:
+1V1: C19.1, C20.1, C22.1, C23.1, L1.1, U3.10 (DVDD), U3.32 (DVDD), U3.51 (DVDD), U3.65 (VREG_FB)
+3V3: C5.1, C12.1, C16.1, C25.1, C26.1, C27.1, C29.1, C30.1, C31.1, C34.1, C36.1, C38.1, R9.1, R25.1, R29.1, R36.1, SW5.2, U2.8 (VCC), U3.5 (IOVDD), U3.15 (IOVDD), U3.24 (IOVDD), U3.29 (IOVDD), U3.41 (IOVDD), U3.50 (IOVDD), U3.60 (IOVDD), U3.64 (VREG_VIN), U3.68 (USB_OTP_VDD), U3.69 (QSPI_IOVDD), U3.76 (IOVDD); also elsewhere on the board
/RP2350B/RUN: SW2.2, U3.35 (RUN)
/RP2350B/VREG_AVDD: C21.1, R25.2, U3.61 (VREG_AVDD)
/RP2350B/VREG_LX: L1.2, U3.63 (VREG_LX)
/RP2350B/XIN: C17.1, U3.30 (XIN), Y1.1
/RP2350B/XOUT: R27.1, U3.31 (XOUT)
ADC0: C28.1, R32.2, R33.1, U3.49 (GPIO40_ADC0); also elsewhere on the board
AMP_SD: U3.48 (GPIO39); also elsewhere on the board
BATPWR: R32.1; also elsewhere on the board
DB0: U3.12 (GPIO13); also elsewhere on the board
DB1: U3.13 (GPIO14); also elsewhere on the board
DB2: U3.14 (GPIO15); also elsewhere on the board
DB3: U3.16 (GPIO16); also elsewhere on the board
DB4: U3.17 (GPIO17); also elsewhere on the board
DB5: U3.18 (GPIO18); also elsewhere on the board
DB6: U3.19 (GPIO19); also elsewhere on the board
DB7: U3.20 (GPIO20); also elsewhere on the board
DB8: U3.21 (GPIO21); also elsewhere on the board
DB9: U3.22 (GPIO22); also elsewhere on the board
DB10: U3.23 (GPIO23); also elsewhere on the board
DB11: U3.25 (GPIO24); also elsewhere on the board
DB12: U3.26 (GPIO25); also elsewhere on the board
DB13: U3.27 (GPIO26); also elsewhere on the board
DB14: U3.28 (GPIO27); also elsewhere on the board
DB15: U3.36 (GPIO28); also elsewhere on the board
GND: C5.2, C12.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C34.2, C36.2, C38.2, J4.2, J4.MP (Shield), R23.2, R33.2, R48.2, SW1.1, SW3.1, U2.4 (GND), U3.62 (VREG_PGND), U3.81 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
I2C0_SCL: U3.42 (GPIO33); also elsewhere on the board
I2C0_SDA: U3.40 (GPIO32); also elsewhere on the board
LORA_AUX: U3.38 (GPIO30); also elsewhere on the board
LORA_M01: U3.39 (GPIO31); also elsewhere on the board
unnamed: C18.1, R27.2, Y1.3
unnamed: J4.1, R28.2
unnamed: J4.3, R26.2
unnamed: R23.1, SW2.1
unnamed: R24.2, SW1.2
unnamed: C24.1, R29.2, U3.59 (ADC_AVDD)
unnamed: R26.1, U3.33 (SWCLK)
unnamed: R28.1, U3.34 (SWD)
unnamed: R31.2, U3.66 (USB_DM)
unnamed: R30.2, U3.67 (USB_DP)
PWM_AUDIO: U3.47 (GPIO38); also elsewhere on the board
QSPI_SCLK: U2.6 (CLK), U3.71 (QSPI_SCLK)
QSPI_SD0: U2.5 (DI/IO_{0}), U3.72 (QSPI_SD0)
QSPI_SD1: U2.2 (DO/IO_{1}), U3.74 (QSPI_SD1)
QSPI_SD2: U2.3 (~WP/IO_{2}), U3.73 (QSPI_SD2)
QSPI_SD3: U2.7 (~HOLD/~RESET/IO_{3}), U3.70 (QSPI_SD3)
QSPI_SS: R9.2, R24.1, U2.1 (~CS), U3.75 (QSPI_SS)
SCH16T_RESET: U3.56 (GPIO45_ADC5); also elsewhere on the board
SCH16T_SYNC: U3.57 (GPIO46_ADC6); also elsewhere on the board
SD_CLK: U3.79 (GPIO2); also elsewhere on the board
SD_CMD: U3.80 (GPIO3); also elsewhere on the board
SD_DAT0: U3.1 (GPIO4); also elsewhere on the board
SD_DAT1: U3.2 (GPIO5); also elsewhere on the board
SD_DAT2: U3.3 (GPIO6); also elsewhere on the board
SD_DAT3: U3.4 (GPIO7); also elsewhere on the board
SD_DETA: U3.8 (GPIO10); also elsewhere on the board
SPI1_CS: U3.52 (GPIO41_ADC1); also elsewhere on the board
SPI1_RX_MISO: U3.55 (GPIO44_ADC4); also elsewhere on the board
SPI1_SCK: U3.53 (GPIO42_ADC2); also elsewhere on the board
SPI1_TX_MOSI: U3.54 (GPIO43_ADC3); also elsewhere on the board
SW_TOGGLE: R36.2, SW3.2, U3.46 (GPIO37)
TFT_DC: U3.9 (GPIO11); also elsewhere on the board
TFT_MOSFET_G: U3.43 (GPIO34); also elsewhere on the board
TFT_RESET: U3.37 (GPIO29); also elsewhere on the board
TFT_SW: R48.1, SW5.1, U3.44 (GPIO35)
TFT_WR: U3.11 (GPIO12); also elsewhere on the board
UART0_RX: U3.78 (GPIO1); also elsewhere on the board
UART0_TX: U3.77 (GPIO0); also elsewhere on the board
UART1_RX: U3.7 (GPIO9); also elsewhere on the board
UART1_TX: U3.6 (GPIO8); also elsewhere on the board
USB_D+: R30.1; also elsewhere on the board
USB_D-: R31.1; also elsewhere on the board
USB_SENS: U3.58 (GPIO47_ADC7); also elsewhere on the board
USR_LED: U3.45 (GPIO36); also elsewhere on the board

Notes on the sheet:
Make sure USB_DP,USB_DM resistors are close to RP2350
E220 M01 移動
12MHz Crystal
移動 GPIO8->10
FLASH
Modyfied
移動 34->36
RP2354B
移動 35->37
移動 31->47
移動 47->31

Notices in the files:
README.md:
**ソースコード本体** (`*.ino`, `*.cpp`, `*.h`, `tools/*.py`): [MIT License](LICENSE)
Map data © OpenStreetMap contributors
