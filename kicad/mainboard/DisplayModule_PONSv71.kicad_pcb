# Repository MasaoC/GPS-TFT-Map_PONS (continued)

## KiCad design kicad/mainboard/DisplayModule_PONSv71.kicad_pcb (continued)

Board: 4 copper layers, 54.7 x 78.5 mm, 149 parts (136 on the bottom side), 120 nets.

## KiCad design kicad/GNSSboard_SAM-M10Q/SAM-M10Q PONSv7 GNSS module.kicad_pcb

Parts:
C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
J1: Conn_01x05_MountingPin; Molex_200528-0050_1x05-1MP_P1.00mm_Horizontal
U2: SAM-M10Q-00B; XCVR_SAM-M10Q-00B; PARTREV R03

Connections:
+3.3V: C2.1, J1.5, U2.2 (V_IO), U2.17 (VCC)
GND: C2.2, C3.2, J1.4, J1.MP (MountPin), U2.1 (GND), U2.4 (GND), U2.5 (GND), U2.6 (GND), U2.10 (GND), U2.11 (GND), U2.15 (GND), U2.16 (GND), U2.20 (GND)
GNSS_RX: J1.2, U2.14 (RXD)
GNSS_TX: J1.3, U2.13 (TXD)
V_BCKUP: C3.1, J1.1, U2.3 (V_BCKP)

Notes on the sheet:
GNSS SAM-M10Q

Board: 2 copper layers, 56.5 x 41.0 mm, 4 parts (3 on the bottom side), 5 nets.

## KiCad design kicad/case_cover/case_cover.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J2: Conn_01x04; FPC_CON 4p 1mm
LED1: VEML7700-TR; LED-SMD_4P-L6.8-W2.4_VEML7700-TR; MPN VEML7700-TR; LCSC Part C504893

Connections:
+3.3V: C1.1, J2.1, LED1.2 (VDD)
GND: C1.2, J2.4, LED1.3 (GND)
I2C0_SCL: J2.2, LED1.1 (SCL)
I2C0_SDA: J2.3, LED1.4 (SDA)

Board: 2 copper layers, 73.0 x 90.5 mm, 3 parts (0 on the bottom side), 4 nets.

## KiCad design kicad/IMU_murata/IMU_murata.kicad_pcb

Parts:
C1, C5: 0.1u; C_0603_1608Metric
C2: 10u; C_0603_1608Metric
C3, C4: 1u; C_0603_1608Metric
IC1: SCH16T-K01-10; SCH16TK0110; Mouser Part Number 81-SCH16T-K01-10
J1: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J3: Conn_01x08_MountingPin; FPC_CON 8p 1mm
R1: 4.7k; R_0603_1608Metric
R2: 4.7k; R_0603_1608Metric; not fitted

Connections:
+3V3: C1.1, C4.1, C5.1, IC1.8 (V3P3_1), IC1.17 (V3P3_2), IC1.18 (VDDIO), J1.1, J3.1, R1.1
/CS: IC1.22 (CS), J1.4, J3.4, R2.1
/HEATSINK: IC1.1 (HEATSINK_1), IC1.24 (HEATSINK_2)
/IMU_RST: IC1.6 (EXTRESN), J1.2, J3.2, R1.2
/MISO: IC1.19 (MISO), J1.7, J3.7
/MOSI: IC1.23 (MOSI), J1.3, J3.3
/SCK: IC1.21 (SCK), J1.5, J3.5
/SYNC: IC1.20 (DRY_SYNC), J1.6, J3.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, IC1.3 (TA9), IC1.4 (TA8), IC1.5 (RESERVED_1), IC1.7 (RESERVED_2), IC1.9 (GND_1), IC1.12 (GND_2), IC1.13 (GND_3), IC1.16 (GND_4), J1.8, J3.8, R2.2
unnamed: C2.1, IC1.10 (VREGA2), IC1.11 (VREGA)
unnamed: C3.1, IC1.14 (VREGD2), IC1.15 (VREGD)

Board: 2 copper layers, 30.6 x 34.3 mm, 10 parts (1 on the bottom side), 11 nets.

## KiCad design kicad/GNSSboard_SAM-M10Q/SAM-M10Q PONSv6 GNSS module.kicad_pcb

Parts:
BT1: MS621FE; BatteryHolder_Seiko_MS621F
C2, C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: RB520S-30; D_SOD-523
J1: 2005280040; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal; MANUFACTURER_PART_NUMBER 2005280040
J2: Conn_01x04_MountingPin; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; LCSC C160404
J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J8: Conn_01x04_Shielded; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; LCSC C160404
R1: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2: SAM-M10Q-00B; XCVR_SAM-M10Q-00B; PARTREV R03

Connections:
+3.3V: C2.1, J1.4, J2.2, J8.2, R1.2, U2.2 (V_IO), U2.17 (VCC)
GND: BT1.2 (-), C2.2, C3.2, J1.3, J1.MP, J2.1, J2.MP (MountPin), J8.1, J8.MP (Shield), U2.1 (GND), U2.4 (GND), U2.5 (GND), U2.6 (GND), U2.10 (GND), U2.11 (GND), U2.15 (GND), U2.16 (GND), U2.20 (GND)
GNSS_RX: J1.1, J2.4, U2.14 (RXD)
GNSS_TX: J1.2, J2.3, U2.13 (TXD)
I2C0_SCL: J8.4, U2.12 (SCL)
I2C0_SDA: J8.3, U2.9 (SDA)
unnamed: BT1.1 (+), R2.1
unnamed: D1.2 (A), R1.1
unnamed: J3.1, U2.18 (~RESET)
unnamed: J3.2, U2.8 (~SAFEBOOT)
unnamed: J3.3, U2.19 (EXTINT)
V_BCKUP: C3.1, D1.1 (K), R2.2, U2.3 (V_BCKP)

Notes on the sheet:
GNSS
突入電流&バッテリー電流制限&最小 V_BCKP 対策 電源ONで、220/690*3.3V が BCKP にかかる
UART1_TX
UART1_RX
BT1が放電しきっていると、モジュールが起動しないバグがあったため、 R7抵抗によって、BT1バッテリーが空っぽでも、V_BCKUPに電圧が生じる((3.3-1)*220/690)とか？ 放電は、V=IR=10*10^-6*470 で、電圧降下はほとんどない P=IV=V^2/R=(0.5*10^-3)^2/500=0.5*10^-9=0.5nW

Board: 2 copper layers, 36.1 x 17.0 mm, 11 parts (9 on the bottom side), 12 nets.

## KiCad design kicad/DisplayModule_PONSv5.kicad_pcb

Parts:
BT1: MS621F; BatteryHolder_Seiko_MS621F
C1, C14: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C10: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C9: 47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6, C7: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: (1500u); CP_Elec_10x10.5
C11, C12: 220p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C15: (220u); C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D1: CHG LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: RB520S-30; D_SOD-523
FB1, FB2: 120; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
J1: Ext. Speaker; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J2: 541324062; CON_541324062_MOL
J4: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5
J5: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
JP1: BAT_ON; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: TFT_ON; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: VBCKP; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
PWR1: 1s Lipo Power input; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
Q2: DMG3415U; SOT-23
R2, R3, R6: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 1-10; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R5: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R10: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14, R15, R16: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18, R19, R20, R21, R22: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 100k; Potentiometer_PVZ3A
SW1: SW0_BOARD; SW_PUSH_6mm_H9.5mm
SW3: BAT_TFT_SW; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1: Pico; RPi_Pico_SMD
U2: MCP73831-2-OT; SOT-23-5
U3: LC86GPAMD; L86_QWS
U4: PAM8302AAD; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C3.1, C4.1, C7.1, C8.1, C9.1, C13.1, C14.1, C15.1, J2.10 (31), J2.28 (13), J2.33 (8), J2.34 (7), J4.4 (VDD), J6.1, JP2.2 (B), JP3.1 (A), R2.1, R3.1, R7.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, SW3.2, U1.30 (RUN), U1.36 (3V3), U3.4 (VCC), U4.6 (VDD)
AMP_SD: U1.14 (GPIO10), U4.1 (~SD)
DB8: J2.19 (22), U1.19 (GPIO14)
DB9: J2.18 (23), U1.20 (GPIO15)
DB10: J2.17 (24), U1.21 (GPIO16)
DB11: J2.16 (25), U1.22 (GPIO17)
DB12: J2.15 (26), U1.24 (GPIO18)
DB13: J2.14 (27), U1.25 (GPIO19)
DB14: J2.13 (28), U1.26 (GPIO20)
DB15: J2.12 (29), U1.27 (GPIO21)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.1, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, J2.2 (39), J2.4 (37), J2.5 (36), J2.6 (35), J2.7 (34), J2.8 (33), J2.31 (10), J2.40 (1), J4.6 (VSS), J4.9 (DET_B), J4.11 (SHIELD), J5.2, J6.2, PWR1.2, R5.2, RV1.3, SW1.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND), U2.2 (V_{SS}), U3.3 (GND), U3.12 (GND), U4.7 (GND)
GPIO11: J6.3, U1.15 (GPIO11)
GPIO12: J6.4, U1.16 (GPIO12)
GPIO13: J6.5, U1.17 (GPIO13)
unnamed: BT1.1 (+), C1.1, C2.1, D2.1 (K), JP3.2 (B), U3.5 (V_BCKP)
unnamed: C5.2, R8.1
unnamed: C6.1, RV1.2
unnamed: C6.2, R9.1
unnamed: C10.2, R10.1, RV1.1
unnamed: D1.2 (A), R6.2
unnamed: D1.1 (K), U2.1 (STAT)
unnamed: D2.2 (A), R7.1
unnamed: C11.1, FB1.2, J1.1
unnamed: C12.1, FB2.2, J1.2
unnamed: J2.3 (38), R3.2, R4.2
unnamed: J4.5 (CLK), R14.2, R20.1
unnamed: J4.3 (CMD), R13.2, R19.1
unnamed: J4.7 (DAT0), R15.2, R21.1
unnamed: J4.8 (DAT1), R16.2, R22.1
unnamed: J4.1 (DAT2), R11.2, R17.1
unnamed: J4.2 (DAT3/CD), R12.2, R18.1
unnamed: J5.1, U1.41 (SWCLK)
unnamed: J5.3, U1.43 (SWDIO)
unnamed: R5.1, U2.5 (PROG)
unnamed: R9.2, U4.3 (IN+)
unnamed: R8.2, U4.4 (IN-)
unnamed: FB2.1, U4.5 (OUT+)
unnamed: FB1.1, U4.8 (OUT-)
PWM_AUDIO: R10.2, U1.12 (GPIO9)
SD_CLK: R14.1, U1.4 (GPIO2)
SD_CMD: R13.1, U1.5 (GPIO3)
SD_DAT0: R15.1, U1.6 (GPIO4)
SD_DAT1: R16.1, U1.7 (GPIO5)
SD_DAT2: R11.1, U1.9 (GPIO6)
SD_DAT3: R12.1, U1.10 (GPIO7)
SD_DETA: J4.10 (DET_A), U1.11 (GPIO8)
SW_GPIO26: R2.2, SW1.1, U1.31 (GPIO26_ADC0)
TFT_DC: J2.30 (11), U1.34 (GPIO28_ADC2)
TFT_PWR: JP2.1 (A), R4.1, SW3.3
TFT_RESET: J2.11 (30), U1.29 (GPIO22)
TFT_WR: J2.29 (12), U1.32 (GPIO27_ADC1)
UART1_RX: U1.2 (GPIO1), U3.2 (TXD1)
UART1_TX: U1.1 (GPIO0), U3.1 (RXD1)
VBAT: JP1.2 (B), Q2.3 (D), SW3.4
VBAT_IN: JP1.1 (A), PWR1.1, SW3.1, U2.3 (V_{BAT})
VBUS: Q2.1 (G), R6.1, U1.40 (VBUS), U2.4 (V_{DD})
VSYS: Q2.2 (S), U1.39 (VSYS)

Notes on the sheet:
Optional SDIO
GNSS
USB to Lipo Charger(Optional)
Bat Discharger For Battery Safety
BAT IN
Optional Speaker
BLM31PG121SN1L
Power SW
(0.1uF+1kΩ Acceptable)
TFT NHD-2.4-240320CF-CSXN#-F
2.2k to limit current

Board: 2 copper layers, 61.0 x 90.5 mm, 58 parts (20 on the bottom side), 57 nets.
