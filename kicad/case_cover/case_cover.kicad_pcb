# Repository MasaoC/GPS-TFT-Map_PONS (continued)

## KiCad design kicad/mainboard/DisplayModule_PONSv71.kicad_pcb (continued)

Parts:
C5: 100u; C_1206_3216Metric; LCSC C15008
C12, C20, C23, C25, C26, C27, C29, C30, C31, C34, C36, C38: 100n; C_0402_1005Metric_small_pads; LCSC C1525
C16, C19, C21, C22, C24: 4.7u; C_0402_1005Metric_small_pads; LCSC C23733
C17, C18: 33p; C_0402_1005Metric_small_pads; LCSC C1562
C28: 1u; C_0402_1005Metric_small_pads; LCSC C52923
J4: Conn_01x03_Shielded; JST_SH_BM03B-SRSS-TB_1x03-1MP_P1.00mm_Vertical; LCSC C160389
L1: 3.3u; L_1008_2520Metric; LCSC C22416628
R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C25804; not fitted
R23, R24, R27, R36: 1k; R_0402_1005Metric; LCSC C11702
R25: 33; R_0402_1005Metric; LCSC C25105
R26, R28: 100; R_0402_1005Metric; LCSC C25076
R29: 200; R_0402_1005Metric; LCSC C25087
R30, R31: 22; R_0402_1005Metric; LCSC C25092
R32: 100k; R_0402_1005Metric; LCSC C25741
R33: 51K; R_0402_1005Metric; LCSC C25794
R48: 4.7k; R_0402_1005Metric; LCSC C25900
SW1, SW2: SW_TS-1088; TS-1088-AR02016; LCSC C720477
SW3: PTS645VK392LFS; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS; LCSC C285519
SW5: MST-12D18G2 SMD SLIDE SWITCH; SW-SMD_3P-L9.1-W3.5-P2.50_MST-12D18G2; MPN MST-12D18G2 SMD Slide Switch; LCSC C49023765
U2: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm; LCSC C97521
U3: RP2350_80QFN; RP2350-QFN-80-1EP_10x10_P0.4mm_EP3.4x3.4mm_ThermalVias; LCSC C42415655
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9002

Connections:
+1V1: C19.1, C20.1, C22.1, C23.1, L1.1, U3.10 (DVDD), U3.32 (DVDD), U3.51 (DVDD), U3.65 (VREG_FB)
+3V3: C5.1, C12.1, C16.1, C25.1, C26.1, C27.1, C29.1, C30.1, C31.1, C34.1, C36.1, C38.1, R9.1, R25.1, R29.1, R36.1, SW5.2, U2.8 (VCC), U3.5 (IOVDD), U3.15 (IOVDD), U3.24 (IOVDD), U3.29 (IOVDD), U3.41 (IOVDD), U3.50 (IOVDD), U3.60 (IOVDD), U3.64 (VREG_VIN), U3.68 (USB_OTP_VDD), U3.69 (QSPI_IOVDD), U3.76 (IOVDD); also elsewhere on the board
/RP2350B/RUN: SW2.2, U3.35 (RUN)
/RP2350B/VREG_AVDD: C21.1, R25.2, U3.61 (VREG_AVDD)
/RP2350B/VREG_LX: L1.2, U3.63 (VREG_LX)
/RP2350B/XIN: C17.1, U3.30 (XIN), Y1.1
/RP2350B/XOUT: R27.1, U3.31 (XOUT)
ADC0: C28.1, R32.2, R33.1, U3.49 (GPIO40_ADC0); also elsewhere on the board
AMP_SD: U3.48 (GPIO39); also elsewhere on the board
BATPWR: R32.1; also elsewhere on the board
DB0: U3.12 (GPIO13); also elsewhere on the board
DB1: U3.13 (GPIO14); also elsewhere on the board
DB2: U3.14 (GPIO15); also elsewhere on the board
DB3: U3.16 (GPIO16); also elsewhere on the board
DB4: U3.17 (GPIO17); also elsewhere on the board
DB5: U3.18 (GPIO18); also elsewhere on the board
DB6: U3.19 (GPIO19); also elsewhere on the board
DB7: U3.20 (GPIO20); also elsewhere on the board
DB8: U3.21 (GPIO21); also elsewhere on the board
DB9: U3.22 (GPIO22); also elsewhere on the board
DB10: U3.23 (GPIO23); also elsewhere on the board
DB11: U3.25 (GPIO24); also elsewhere on the board
DB12: U3.26 (GPIO25); also elsewhere on the board
DB13: U3.27 (GPIO26); also elsewhere on the board
DB14: U3.28 (GPIO27); also elsewhere on the board
DB15: U3.36 (GPIO28); also elsewhere on the board
GND: C5.2, C12.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C34.2, C36.2, C38.2, J4.2, J4.MP (Shield), R23.2, R33.2, R48.2, SW1.1, SW3.1, U2.4 (GND), U3.62 (VREG_PGND), U3.81 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
I2C0_SCL: U3.42 (GPIO33); also elsewhere on the board
I2C0_SDA: U3.40 (GPIO32); also elsewhere on the board
LORA_AUX: U3.38 (GPIO30); also elsewhere on the board
LORA_M01: U3.39 (GPIO31); also elsewhere on the board
unnamed: C18.1, R27.2, Y1.3
unnamed: J4.1, R28.2
unnamed: J4.3, R26.2
unnamed: R23.1, SW2.1
unnamed: R24.2, SW1.2
unnamed: C24.1, R29.2, U3.59 (ADC_AVDD)
unnamed: R26.1, U3.33 (SWCLK)
unnamed: R28.1, U3.34 (SWD)
unnamed: R31.2, U3.66 (USB_DM)
unnamed: R30.2, U3.67 (USB_DP)
PWM_AUDIO: U3.47 (GPIO38); also elsewhere on the board
QSPI_SCLK: U2.6 (CLK), U3.71 (QSPI_SCLK)
QSPI_SD0: U2.5 (DI/IO_{0}), U3.72 (QSPI_SD0)
QSPI_SD1: U2.2 (DO/IO_{1}), U3.74 (QSPI_SD1)
QSPI_SD2: U2.3 (~WP/IO_{2}), U3.73 (QSPI_SD2)
QSPI_SD3: U2.7 (~HOLD/~RESET/IO_{3}), U3.70 (QSPI_SD3)
QSPI_SS: R9.2, R24.1, U2.1 (~CS), U3.75 (QSPI_SS)
SCH16T_RESET: U3.56 (GPIO45_ADC5); also elsewhere on the board
SCH16T_SYNC: U3.57 (GPIO46_ADC6); also elsewhere on the board
SD_CLK: U3.79 (GPIO2); also elsewhere on the board
SD_CMD: U3.80 (GPIO3); also elsewhere on the board
SD_DAT0: U3.1 (GPIO4); also elsewhere on the board
SD_DAT1: U3.2 (GPIO5); also elsewhere on the board
SD_DAT2: U3.3 (GPIO6); also elsewhere on the board
SD_DAT3: U3.4 (GPIO7); also elsewhere on the board
SD_DETA: U3.8 (GPIO10); also elsewhere on the board
SPI1_CS: U3.52 (GPIO41_ADC1); also elsewhere on the board
SPI1_RX_MISO: U3.55 (GPIO44_ADC4); also elsewhere on the board
SPI1_SCK: U3.53 (GPIO42_ADC2); also elsewhere on the board
SPI1_TX_MOSI: U3.54 (GPIO43_ADC3); also elsewhere on the board
SW_TOGGLE: R36.2, SW3.2, U3.46 (GPIO37)
TFT_DC: U3.9 (GPIO11); also elsewhere on the board
TFT_MOSFET_G: U3.43 (GPIO34); also elsewhere on the board
TFT_RESET: U3.37 (GPIO29); also elsewhere on the board
TFT_SW: R48.1, SW5.1, U3.44 (GPIO35)
TFT_WR: U3.11 (GPIO12); also elsewhere on the board
UART0_RX: U3.78 (GPIO1); also elsewhere on the board
UART0_TX: U3.77 (GPIO0); also elsewhere on the board
UART1_RX: U3.7 (GPIO9); also elsewhere on the board
UART1_TX: U3.6 (GPIO8); also elsewhere on the board
USB_D+: R30.1; also elsewhere on the board
USB_D-: R31.1; also elsewhere on the board
USB_SENS: U3.58 (GPIO47_ADC7); also elsewhere on the board
USR_LED: U3.45 (GPIO36); also elsewhere on the board

Notes on the sheet:
Make sure USB_DP,USB_DM resistors are close to RP2350
E220 M01 移動
12MHz Crystal
移動 GPIO8->10
FLASH
Modyfied
移動 34->36
RP2354B
移動 35->37
移動 31->47
移動 47->31

Board: 4 copper layers, 56.3 x 84.9 mm, 166 parts (153 on the bottom side), 131 nets.

## KiCad design kicad/GNSSboard_SAM-M10Q/SAM-M10Q PONSv7 GNSS module.kicad_pcb

Parts:
C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; not fitted
J1: Conn_01x05_MountingPin; Molex_200528-0050_1x05-1MP_P1.00mm_Horizontal
U2: SAM-M10Q-00B; XCVR_SAM-M10Q-00B; PARTREV R03

Connections:
+3.3V: C2.1, J1.5, U2.2 (V_IO), U2.17 (VCC)
GND: C2.2, C3.2, J1.4, J1.MP (MountPin), U2.1 (GND), U2.4 (GND), U2.5 (GND), U2.6 (GND), U2.10 (GND), U2.11 (GND), U2.15 (GND), U2.16 (GND), U2.20 (GND)
GNSS_RX: J1.2, U2.14 (RXD)
GNSS_TX: J1.3, U2.13 (TXD)
V_BCKUP: C3.1, J1.1, U2.3 (V_BCKP)

Notes on the sheet:
GNSS SAM-M10Q

Board: 2 copper layers, 56.5 x 41.0 mm, 4 parts (3 on the bottom side), 5 nets.

## KiCad design kicad/IMU_murata/IMU_murata.kicad_pcb

Parts:
C1, C5: 0.1u; C_0603_1608Metric
C2: 10u; C_0603_1608Metric
C3, C4: 1u; C_0603_1608Metric
IC1: SCH16T-K01-10; SCH16TK0110; Mouser Part Number 81-SCH16T-K01-10
J1: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J3: Conn_01x08_MountingPin; FPC_CON 8p 1mm
R1: 4.7k; R_0603_1608Metric
R2: 4.7k; R_0603_1608Metric; not fitted

Connections:
+3V3: C1.1, C4.1, C5.1, IC1.8 (V3P3_1), IC1.17 (V3P3_2), IC1.18 (VDDIO), J1.1, J3.1, R1.1
/CS: IC1.22 (CS), J1.4, J3.4, R2.1
/HEATSINK: IC1.1 (HEATSINK_1), IC1.24 (HEATSINK_2)
/IMU_RST: IC1.6 (EXTRESN), J1.2, J3.2, R1.2
/MISO: IC1.19 (MISO), J1.7, J3.7
/MOSI: IC1.23 (MOSI), J1.3, J3.3
/SCK: IC1.21 (SCK), J1.5, J3.5
/SYNC: IC1.20 (DRY_SYNC), J1.6, J3.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, IC1.3 (TA9), IC1.4 (TA8), IC1.5 (RESERVED_1), IC1.7 (RESERVED_2), IC1.9 (GND_1), IC1.12 (GND_2), IC1.13 (GND_3), IC1.16 (GND_4), J1.8, J3.8, R2.2
unnamed: C2.1, IC1.10 (VREGA2), IC1.11 (VREGA)
unnamed: C3.1, IC1.14 (VREGD2), IC1.15 (VREGD)

Board: 2 copper layers, 30.6 x 34.3 mm, 10 parts (1 on the bottom side), 11 nets.

## KiCad design kicad/GNSSboard_SAM-M10Q/SAM-M10Q PONSv6 GNSS module.kicad_pcb

Parts:
BT1: MS621FE; BatteryHolder_Seiko_MS621F
C2, C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: RB520S-30; D_SOD-523
J1: 2005280040; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal; MANUFACTURER_PART_NUMBER 2005280040
J2: Conn_01x04_MountingPin; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; LCSC C160404
J3: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J8: Conn_01x04_Shielded; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal; LCSC C160404
R1: 220; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2: SAM-M10Q-00B; XCVR_SAM-M10Q-00B; PARTREV R03

Connections:
+3.3V: C2.1, J1.4, J2.2, J8.2, R1.2, U2.2 (V_IO), U2.17 (VCC)
GND: BT1.2 (-), C2.2, C3.2, J1.3, J1.MP, J2.1, J2.MP (MountPin), J8.1, J8.MP (Shield), U2.1 (GND), U2.4 (GND), U2.5 (GND), U2.6 (GND), U2.10 (GND), U2.11 (GND), U2.15 (GND), U2.16 (GND), U2.20 (GND)
GNSS_RX: J1.1, J2.4, U2.14 (RXD)
GNSS_TX: J1.2, J2.3, U2.13 (TXD)
I2C0_SCL: J8.4, U2.12 (SCL)
I2C0_SDA: J8.3, U2.9 (SDA)
unnamed: BT1.1 (+), R2.1
unnamed: D1.2 (A), R1.1
unnamed: J3.1, U2.18 (~RESET)
unnamed: J3.2, U2.8 (~SAFEBOOT)
unnamed: J3.3, U2.19 (EXTINT)
V_BCKUP: C3.1, D1.1 (K), R2.2, U2.3 (V_BCKP)

Notes on the sheet:
GNSS
突入電流&バッテリー電流制限&最小 V_BCKP 対策 電源ONで、220/690*3.3V が BCKP にかかる
UART1_TX
UART1_RX
BT1が放電しきっていると、モジュールが起動しないバグがあったため、 R7抵抗によって、BT1バッテリーが空っぽでも、V_BCKUPに電圧が生じる((3.3-1)*220/690)とか？ 放電は、V=IR=10*10^-6*470 で、電圧降下はほとんどない P=IV=V^2/R=(0.5*10^-3)^2/500=0.5*10^-9=0.5nW

Board: 2 copper layers, 36.1 x 17.0 mm, 11 parts (9 on the bottom side), 12 nets.

## KiCad design kicad/DisplayModule_PONSv5.kicad_pcb

Parts:
BT1: MS621F; BatteryHolder_Seiko_MS621F
C1, C14: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C4, C10: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C9: 47u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6, C7: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: (1500u); CP_Elec_10x10.5
C11, C12: 220p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C15: (220u); C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
D1: CHG LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: RB520S-30; D_SOD-523
FB1, FB2: 120; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
J1: Ext. Speaker; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
J2: 541324062; CON_541324062_MOL
J4: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5
J5: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
JP1: BAT_ON; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: TFT_ON; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: VBCKP; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
PWR1: 1s Lipo Power input; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
Q2: DMG3415U; SOT-23
R2, R3, R6: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 1-10; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R5: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R10: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14, R15, R16: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18, R19, R20, R21, R22: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 100k; Potentiometer_PVZ3A
SW1: SW0_BOARD; SW_PUSH_6mm_H9.5mm
SW3: BAT_TFT_SW; SW_DIP_SPSTx02_Slide_9.78x7.26mm_W7.62mm_P2.54mm
U1: Pico; RPi_Pico_SMD
U2: MCP73831-2-OT; SOT-23-5
U3: LC86GPAMD; L86_QWS
U4: PAM8302AAD; SO-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C3.1, C4.1, C7.1, C8.1, C9.1, C13.1, C14.1, C15.1, J2.10 (31), J2.28 (13), J2.33 (8), J2.34 (7), J4.4 (VDD), J6.1, JP2.2 (B), JP3.1 (A), R2.1, R3.1, R7.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, SW3.2, U1.30 (RUN), U1.36 (3V3), U3.4 (VCC), U4.6 (VDD)
AMP_SD: U1.14 (GPIO10), U4.1 (~SD)
DB8: J2.19 (22), U1.19 (GPIO14)
DB9: J2.18 (23), U1.20 (GPIO15)
DB10: J2.17 (24), U1.21 (GPIO16)
DB11: J2.16 (25), U1.22 (GPIO17)
DB12: J2.15 (26), U1.24 (GPIO18)
DB13: J2.14 (27), U1.25 (GPIO19)
DB14: J2.13 (28), U1.26 (GPIO20)
DB15: J2.12 (29), U1.27 (GPIO21)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.1, C7.2, C8.2, C9.2, C10.1, C11.2, C12.2, C13.2, C14.2, C15.2, J2.2 (39), J2.4 (37), J2.5 (36), J2.6 (35), J2.7 (34), J2.8 (33), J2.31 (10), J2.40 (1), J4.6 (VSS), J4.9 (DET_B), J4.11 (SHIELD), J5.2, J6.2, PWR1.2, R5.2, RV1.3, SW1.2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND), U2.2 (V_{SS}), U3.3 (GND), U3.12 (GND), U4.7 (GND)
GPIO11: J6.3, U1.15 (GPIO11)
GPIO12: J6.4, U1.16 (GPIO12)
GPIO13: J6.5, U1.17 (GPIO13)
unnamed: BT1.1 (+), C1.1, C2.1, D2.1 (K), JP3.2 (B), U3.5 (V_BCKP)
unnamed: C5.2, R8.1
unnamed: C6.1, RV1.2
unnamed: C6.2, R9.1
unnamed: C10.2, R10.1, RV1.1
unnamed: D1.2 (A), R6.2
unnamed: D1.1 (K), U2.1 (STAT)
unnamed: D2.2 (A), R7.1
unnamed: C11.1, FB1.2, J1.1
unnamed: C12.1, FB2.2, J1.2
unnamed: J2.3 (38), R3.2, R4.2
unnamed: J4.5 (CLK), R14.2, R20.1
unnamed: J4.3 (CMD), R13.2, R19.1
unnamed: J4.7 (DAT0), R15.2, R21.1
unnamed: J4.8 (DAT1), R16.2, R22.1
unnamed: J4.1 (DAT2), R11.2, R17.1
unnamed: J4.2 (DAT3/CD), R12.2, R18.1
unnamed: J5.1, U1.41 (SWCLK)
unnamed: J5.3, U1.43 (SWDIO)
unnamed: R5.1, U2.5 (PROG)
unnamed: R9.2, U4.3 (IN+)
unnamed: R8.2, U4.4 (IN-)
unnamed: FB2.1, U4.5 (OUT+)
unnamed: FB1.1, U4.8 (OUT-)
PWM_AUDIO: R10.2, U1.12 (GPIO9)
SD_CLK: R14.1, U1.4 (GPIO2)
SD_CMD: R13.1, U1.5 (GPIO3)
SD_DAT0: R15.1, U1.6 (GPIO4)
SD_DAT1: R16.1, U1.7 (GPIO5)
SD_DAT2: R11.1, U1.9 (GPIO6)
SD_DAT3: R12.1, U1.10 (GPIO7)
SD_DETA: J4.10 (DET_A), U1.11 (GPIO8)
SW_GPIO26: R2.2, SW1.1, U1.31 (GPIO26_ADC0)
TFT_DC: J2.30 (11), U1.34 (GPIO28_ADC2)
TFT_PWR: JP2.1 (A), R4.1, SW3.3
TFT_RESET: J2.11 (30), U1.29 (GPIO22)
TFT_WR: J2.29 (12), U1.32 (GPIO27_ADC1)
UART1_RX: U1.2 (GPIO1), U3.2 (TXD1)
UART1_TX: U1.1 (GPIO0), U3.1 (RXD1)
VBAT: JP1.2 (B), Q2.3 (D), SW3.4
VBAT_IN: JP1.1 (A), PWR1.1, SW3.1, U2.3 (V_{BAT})
VBUS: Q2.1 (G), R6.1, U1.40 (VBUS), U2.4 (V_{DD})
VSYS: Q2.2 (S), U1.39 (VSYS)

Notes on the sheet:
Optional SDIO
GNSS
USB to Lipo Charger(Optional)
Bat Discharger For Battery Safety
BAT IN
Optional Speaker
BLM31PG121SN1L
Power SW
(0.1uF+1kΩ Acceptable)
TFT NHD-2.4-240320CF-CSXN#-F
2.2k to limit current
