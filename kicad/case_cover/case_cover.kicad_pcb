# Repository MasaoC/GPS-TFT-Map_PONS

File README.md (part):

# PONS — 鳥人間コンテスト向け 人力飛行機用 GPS/GNSS ナビ（航法装置）v7.1

**PONS（Pilot Oriented Navigation System）**は、人力飛行機のパイロットが使いやすいことを目標とした航法装置です。琵琶湖の鳥人間コンテストに特化しています。  
鳥人間チームの電装（パイロット用の計器・GPS ナビ）として、地図・対地速度・方位・姿勢・昇降計（バリオ）・風向風速を 1 つの画面と音声で伝えます。
基板（KiCad）・ファームウェア（Arduino）・3D プリントケースのデータをオープンソースで公開しています。  
GPS/GNSS navigation for human-powered aircraft, specialized for the Japan International Birdman Rally at Lake Biwa, Japan. → [English summary](#english-summary)

* **使用実績**：大阪大学 albatross（2024 追走ボート: v3 / 2025 追走ボート: v4 / 2025 機体搭載「白夜」: v5 /
  2026 追走ボート: v6 / 2026 機体搭載「陽還」: v6β）。**2025 年大会優勝。**
* **本ブランチ（`PONSv7.1`）は 2027・2028 年大会向け v7.1 基板専用です。**  
  姿勢センサーを Murata SCH16T-K01（外付け FPC）とし、電源回路の安全対策（Q3/Q4/F1/U10）を施した最新設計です。  
  BNO085 搭載の初代 v7 基板は廃止しました（2026-11-22）。
* **v3〜v6 ブランチが実際にフライト利用した実績のある安定版です。** v7.1 はまだ大会で使っていません。

ファームウェア **1.17**（2026-11-28）。PONS Link の無線形式は `0xC4` です。送受信機は同じ形式で使用してください。

**大会・試験飛行の当日はこちら → [出発前の READY 確認](#ready-になる条件)**

---

## PONS を導入するメリット

**飛んでいる間の「道具」であり、飛んだあとの「計測器」でもあります。** 当日の誘導と、次期機体の設計の両方に活用できます。

### 鳥人間コンテストに特化している点
* **パイロット中心設計**: 直射日光下（1000ニト高輝度 TFT）や騒音・ペダリング負荷のなかでも、画面を注視せず音声警報だけでコースやバンク角を把握可能。
* **Auto 10km 自動誘導**: プラットホーム離脱から 10km 折り返し、帰還までを距離判定で自動認識・案内（→ [大会本番での使い方](#大会本番での使い方auto-10km-モード)）。
* **機上風向・風速推定**: 対気速度センサー不要で、ピッチ角と対地速度から機上で風向・風速ベクトルをリアルタイム推定（→ [風の推定](#風の推定)）。
* **PONS Link（機体⇄ボート テレメトリ）**: 920MHz 帯 LoRa により、ボート側の受信機へ機体の航法画面・風情報・警報音をリアルタイムで完全ミラーリング（→ [PONS Link](#pons-link機体ボート-テレメトリ無線)）。

### 次期機体の設計へのフィードバック
SD カードのログを付属ツール（`tools/`）で解析し、機体特性の定量評価が可能です。
* **縦の癖**: フゴイド周期の同定、対気速度の分散推定、巡航余裕度の確認。
* **横の癖**: 上反角・ラダー効果に起因するロール／ヨーの固有周期分析。
* **構造荷重の検証**: 巡航中の鉛直加速度（実測最大 +0.18 / −0.25 G、荷重倍数 1.17 / 0.77）から主桁設計荷重を裏付け。

---

## ドキュメント一覧

| ドキュメント | 対象・内容 |
|---|---|
| **[docs 案内](docs/README.md)** | 開発・製作・機能仕様・設計メモ・TODO の一覧 |
| **[PONS_HPA v7.1 説明書](https://docs.google.com/document/d/1KvTG9RTmQfcqMZj5Lb0X9cOWW-vuLJjpPzH3PTkBcsk/)** | **パイロット・ボートマン向け**。操作手順、画面の見方、警告音の意味、大会当日の運用手順（Google Docs） |
| **この README** | **開発者・自作者向け**。アーキテクチャ、設計根拠、ハードウェア構成、SD 構成、解析ツール |

---

## スペック (v7.1)

| 項目 | 仕様 |
|---|---|
| **外形寸法 / 重量** | W59 × H81 × D20 mm / 約 62g（ケース込） |
| **ディスプレイ** | 2.8 インチ **1000 ニト** 高輝度 TFT（Newhaven NHD-2.8-240320AF-CSXP-F）。自動調光対応 |
| **GNSS** | u-blox SAM-M10Q（位置の表示・記録は 2Hz、姿勢推定には 4Hz の速度を使う〔v7.1〕、位置精度 1.5m、AssistNow Autonomous 対応、ファーム ROM SPG 5.10） |
| **気圧センサー** | MS5611（約 40Hz 計測・約 4Hz でバリオ KF へ融合、2Hz SD 記録） |
| **モーションセンサー** | Murata **SCH16T-K01-10**（外付けフレキ、SPI1 250Hz ポーリング） |
| **姿勢推定** | **機上 250Hz ESKF**（GNSS 航跡ヨー注入 ＋ 2Hz 重力観測レベリング） |
| **昇降計（バリオ）** | **KF 融合**（SCH16T 鉛直加速度 ＋ MS5611 気圧高度。デッドバンド ±0.20m/s） |
| **無線 (PONS Link)** | 920MHz LoRa（E220-900T22S(JP)、技適取得済・免許不要、送信 13dBm / 到達実測 **350m**） |
| **バッテリー / 電源** | LiPo 860mAh、USB-C 充電（303mA）。電源スイッチ後段ロードスイッチ Q3、逆接保護 Q4、過電圧保護 U10 |
| **稼働時間** | 輝度 High で約 3 時間。Low（自動調光・待機減光有効）で大幅に延長 |
| **ストレージ** | 内蔵 16MB FLASH（W25Q128：ベクタ地図・音声 44 ファイル・起動ロゴ）、microSD（ログ記録） |

---

## 設計と根拠

### 1. 姿勢推定（ESKF: 誤差状態カルマンフィルター）
内蔵フュージョンチップ（BNO085 等）は協調旋回時に比力横成分がゼロになるためロール角を過小評価し、地磁気方位も機体電子機器の影響で 30° 以上狂う課題がありました。  
本システムでは **生のジャイロ・加速度（SCH16T）** と **GNSS 航跡・対地速度** をカルマンフィルター（ESKF）で機上融合しています。
* **初期水平化**: 静止 2 秒間の平均比力から初期ロール・ピッチを決定。
* **初期ヨー注入**: 発進滑走時、対地速度 2 m/s 以上が 1 秒続いたら発進加速の 2D 相関で真方位を注入。相関の門で外れたときは 3 m/s 以上を待って航跡（True Track）から注入（接地中は横滑り角が原理的にゼロのため、航跡＝機首方位）。
* **重力観測（レベリング）**: 準定常直進時（旋回レート小、$\|a\| \approx 1g$）に比力水平成分を 2Hz で観測更新し、GNSS 途絶時でもロール・ピッチの長期ドリフトを防止（実機走行試験で誤差中央値 21.3° → 1.3° に抑制）。

### 2. 風の推定と推定 TAS
定常飛行時の揚力平衡式 $L = W = \frac{1}{2}\rho V^2 S C_L$ と揚力傾斜の線形近似から、平均迎角 $\alpha$ [deg] を使って TAS を推定します。

$$V(\alpha) = V_0 \sqrt{\frac{m}{93.8\,\mathrm{kg}}\,\frac{K}{K + \alpha}}$$

* **係数は機体・重量・重心で変わるため、SD カードの `settings.txt` で設定可能**:
  | キー | 意味 | 既定値 | 設定範囲 |
  |---|---|---|---|
  | `airspeed_v0` | $V_0$: 設計総重量のピッチ 0 度での巡航対気速度 [m/s] | 7.07 | 3〜20 |
  | `airspeed_k` | $K$: θ=0 の姿勢から揚力ゼロの姿勢までの角度（取付角 − 零揚力角）[度] | 10.00 | 3〜60 |
  | `airspeed_weight_kg` | 機体・パイロット・装備を含む飛行時総重量 [kg] | 93.80 | 50〜150 |
  | `airspeed_min` | 推定対気速度の下限 [m/s] | 5.80 | 1〜20 |
  | `airspeed_max` | 推定対気速度の上限 [m/s] | 9.90 | 1〜25 |

  Re:PONS の「本体設定 → 推定 TAS・風」で総重量を入力すると、設計総重量 93.8 kg に対する重量補正が曲線に反映される。
  `airspeed_min` ≥ `airspeed_max` のときは両方を既定（5.80〜9.90）に戻して log.txt の `ERR airspeed_min ...` に残す。
* α は過去 10 秒の平均ピッチから経路角 γ を引いた、APPLY 基準の平均迎角。$m$ は飛行時総重量。
* $\text{風ベクトル} = \text{対地速度ベクトル} - \text{対気速度ベクトル}$（対気速度の向き＝機首方位）により算出。
* ヘッダー右の大きい枠の既定は **推定 TAS**。IMU/ESKF 画面 1 ページ目、または `settings.txt` の `header_tas:0` で平均迎角（ᾱ）に切り替えられる。
  青い箱に白字・縦書きの `TAS`。地上は数字に白い横線と `GROUND` の札が入る。対地速度 2m/s 以上で札が `WAIT 10s` の残り秒数に変わり、それが 10 秒続くと線も取れる（1m/s 未満が 5 秒続くと線が戻る）。上下限に張り付いたら灰色の箱。
  較正のやり直しが要るときは赤い線と `CALIBRATE`、GNSS の速度が来ていないときは橙の線と `NO GNSS` の札、GNSS は来ているが向きがまだ決まっていない（止まっている間。2〜3m/s 以上で動けば決まる）ときは黄色の線と `YAW ALIGN` の札（平均ピッチの箱も同じ）。
  平均ピッチ `P̄` は地図の瞬間ピッチ `P` のすぐ上。TAS の案内の曲線は、横軸が平均迎角 `ᾱ`。
  V/S が欠測中・復帰待ちのときは灰色の箱に `--`。取り付け 1° で約 0.4 m/s ずれます。仕組みと精度は **[docs/pons_tas.md](docs/pons_tas.md)**。
* 旋回中の横滑り角による誤差混入を防ぐため、直進が累計 10 秒以上継続した場合のみ更新。
* `settings.txt` は本体が保存のたびに書き直します（書き込んだコメント行は消えるため、メモは別ファイルに残してください）。
  `settings.new` に書き切り、前の `settings.txt` を `settings.tmp` に退避して入れ替えます。途中で止まり `settings.txt` が無いときは、`settings.tmp` を復元します。

### 3. GNSS の起動を速くする（AssistNow Autonomous）
GNSS の時計と受信した軌道データ（エフェメリス）をバックアップ電池（BT1、MS621FE）で保つので、最後に測位してから約 4 時間以内なら
**起動から数秒で測位** します（ホットスタート）。それより後でも、SAM-M10Q が自律予測した数日先までの衛星軌道（AssistNow Autonomous。ANA）を
BT1 で保つので、最後の測位から約 3 日以内なら多くは速く測位します（データシートは 2 日前のデータで 4 秒。通常のコールドスタートは 23 秒〜、
小さいアンテナや悪い空では数分）。それより後は、時計が残っていても暦を読み直すのでコールドに近くなります。
ANA は BT1 が切れていた起動でも有効のままです（`settings.h` の `GNSS_ANA_OFF_ON_COLD` = 0。切ると SD のデータベースの予測軌道が使われないため）。

- **SD の航法データベース**: 通電中に GNSS の航法データベース（UBX-MGA-DBD）を SD の `gnss_dbd.bin` へ写しておき、起動時に時計が死んでいた
  ときだけ GNSS へ戻します（`gnss_dbd.cpp`。保存は止まっているときだけ）。予測軌道が入っているので、保存から約 3 日以内なら効く見込みです。
  `log.txt` の `GNSS FIXED ... after boot rtc=lost dbd=40/52 resend=52/52 time=14.2s` に、戻した結果と測位までの秒数が出ます。
- **外から時刻を入れる**: 時刻を知らない GNSS は戻したデータベースの一部を断るので、PC につないでいれば Re:PONS が送る PC の時刻を、
  無線では仲間（機体のテレメトリ・ボートの時刻のビーコン）の時刻を、精度つきで GNSS へ入れます（`gnss_dbd_give_time()` 1 か所に集約）。
- **衛星系**: 起動時に GNSS の衛星系の設定（CFG-SIGNAL）を読んで `log.txt` の `GNSS SIGNAL ...` に残します。BeiDou は工場出荷の B1C のまま
  （B1I は GLONASS と同時に使えず、試すと妨害の指標が上がった）。QZSS が使われなかった件はアンテナ（受け方）の問題と分かり、新しい GNSS 基板では測位に使われています
  （2026-11-18 確認。衛星ごとの状態は `GNSS QZSS (...)` の行。[docs/pons_todo_notes.md](docs/pons_todo_notes.md)）。
- **机の上の試験**: USB シリアルの `PONS:DBD,COLD` / `COLDONLY` / `HOT` / `SAVE` / `STATUS`、`COLD,TIME` / `COLDONLY,TIME`
  （[docs/pons_webserial_protocol.md](docs/pons_webserial_protocol.md)）。
- GNSS DETAIL 3 の下の 2 行は受け方の指標です: `RF jam:12 50+:3/60 noise:91 agc:4464`（`50+` は直近 60 秒で妨害の指標 jamInd が 50 以上だった秒数。
  6 以上で橙、18 以上で赤）と `C/N0 top4:30.8 mean:24.7 trk:14`。`log.txt` の `grf` 行と同じ物差しです。

計画と根拠は [docs/pons_ttff_assist_plan.md](docs/pons_ttff_assist_plan.md)。

### 4. PONS Link（機体⇄ボート テレメトリ無線）
* 送信機（機体）から受信機（ボート）へ、**32 バイト固定フレーム**（印 `0xC4`、回転枠は 4 バイト）を送信（テレメトリは下り一方向）。
  グループは A〜D（`settings.txt` の `link_group:B`）。推定 TAS・平均迎角・平均ピッチは毎回、風・ヨー精度・ヘッダー設定・状態 3 項目は 4 フレームに 1 回。
* 電波法適合のため、標準ではローワーバンド（CH0/3/6/9/12、SF8、1Hz）を使用し、混雑時はアッパーバンド（CH15/21/27）へ退避可能。
* **GNSS の時刻の助け合い**（2026-11-13〜）: BT1 が切れて GNSS が時刻を知らない機体・ボートへ、時刻を持つ仲間が精度つきで時刻を渡す
  （印 `0x58` の 32 バイトのビーコン）。機体は時刻をもらう間だけ送信の合間も受信し、受信機の WIRELESS 画面に ` TIME?` と出ます。
  機体が上りで変えるのは「GNSS へ時刻を 1 回入れる」ことだけです。`settings.txt` の `link_assist:OFF` で止められます（既定 ON）。
* 詳細は **[docs/pons_link.md](docs/pons_link.md)** を参照してください。

### 5. 対地速度で切り替わるもの（開発者向けの一覧）
対地速度の門の一覧（2026-11-22、1.11 の値）。値と理由は `settings.h` の各定数のコメントが正で、ここは索引です。
門を足す・変えるときはこの表も直してください。**「飛んでいる」の門は 2 m/s、地上へ戻す側は 1 m/s** にそろえてあります
（強い向かい風では対地 2〜3 m/s で飛ぶことがあるため。2 m/s 未満では飛ばない前提）。3 m/s に残っているのは、
間違えると次の飛行まで残るもの（自動ロールトリム）と、間違えると向きが 90°・180° ずれるもの（ヨーを航跡で入れる）だけです。

見る速さの「自機」は自機の GNSS（`gnss_get_own_fix()`。ミラー・デモ・リプレイの値は使わない）、「表示の供給元」は `get_gnss_mps()`
（ミラー中は機体、デモ中は仮の値）、「信用できる GNSS」は ESKF が sAcc などで選んだ測位、「ESKF」は ESKF が積分した速度 `v_` です。

| 対地速度 | 何が起きるか | 続く時間 | 見る速さ | 定数 |
|---|---|---|---|---|
| 0.2 m/s | ESKF が「止まった／動いている」とみなす（加速中は重力へ寄せない門） | — | 信用できる GNSS | `ESKF_ACCEL_GNSS_STOP_MPS` / `ESKF_ACCEL_GNSS_MOVING_MPS`（動いている側は sAcc × `ESKF_ACCEL_GNSS_MOVING_SACC_K` が大きければそちら） |
| 0.2 m/s 以下 | リプレイの「飛行区間のみ」で飛ばす静止の行 | — | CSV の gs | `REPLAY_MIN_GS` |
| 0.3 未満 / 0.6 以上 | 待機中の自動減光に入る／抜ける | 入るのは 30 秒 | 自機（受信機のミラー中は自機と送信機の両方） | `BL_DIM_SPEED_ENTER` / `BL_DIM_SPEED_EXIT` |
| 0.8 m/s | ヨーの 2D 相関（発進加速）の積算を始める | — | 信用できる GNSS | `ESKF_YAW_CORR_MIN_GS_MPS` |
| 1.0 m/s 以下 | 本番前チェックの「止まっている」（準備完了の読み上げ）・GNSS の DBD の吸い出し | 読み上げ 5 秒・DBD 30 秒 | 自機 | `READY_STILL_MPS` |
| 1.0 m/s 以下 | 地上の姿勢チェックと APPLY（水平較正）を受け付ける | — | 表示の供給元（デモ・リプレイ・ミラー中は別の扱い） | `LEVEL_CALIB_MAX_MPS` |
| 1.0 m/s 未満 | ESKF の「地上」（止まっている間の再水平化・ゼロ点の学習など） | — | 信用できる GNSS | `ESKF_GROUND_MAX_GS_MPS` |
| 1.0 m/s 未満 | 推定 TAS を地上の横線に戻す | 5 秒 | 表示の供給元 | `TAS_GND_GS_MPS` / `TAS_LAND_HOLD_MS` |
| 1.0 m/s 以下 | 風を捨てる | — | ESKF | `WIND_MIN_SPEED_MPS` |
| 1.5 m/s 超（3·sAcc が大きければそちら） | 移動中: 充電ポップアップを出さない・「SW OFF のまま充電」を見ない | 3 秒（戻るのは 30 秒止まってから） | 自機 | `CHARGE_SW_MOVING_MPS` |
| 2.0 m/s | ナビの警告と表示（コース逸脱の積算・航跡 15° の警告・旋回の音と色・ヘッダーの文字の灰色） | — | 表示の供給元 | `NAV_MIN_GS_MPS` |
| 2.0 m/s 以上 | 地図以外の画面を出したまま動き出したら地図へ戻す（最後のボタン操作から 10 秒たってから。TAS 曲線は 60 秒） | 5 秒（TAS 曲線は 60 秒） | 自機 | `SCREEN_MOVING_EXIT_GS_MPS` |
| 2.0 m/s 以上 | 推定 TAS の「GROUND」の札を外して「WAIT 10s」、続いたら横線も外す | 札はすぐ・線は 10 秒 | 表示の供給元 | `TAS_AIR_GS_MPS` |
| 2.0 m/s 超 | 直進中の風を更新する（表示までにおよそ 10 秒） | — | ESKF | `WIND_UPDATE_MIN_SPEED_MPS` |
| 2.0 m/s 以上 | ヨーを 2D 相関で確定する（相関の門を全部通ったときだけ） | 1 秒 | 信用できる GNSS | `ESKF_YAW_INIT_CORR_MIN_SPEED_MPS` |
| 2.0 m/s 以上 | 受信機（ボート）の自船の方位を出す | — | 自機 | `OWNPOS_TRACK_MIN_MPS` |
| 3.0 m/s 超 | 直進中の自動ロールトリム（覚えた値は SD に残る） | 60 秒の窓が 2 回 | ESKF | `ROLL_TRIM_MIN_SPEED` |
| 3.0 m/s 以上 | ヨーを航跡で入れる（相関で外れたとき）・置き直したあとの方位を航跡で確かめる・止まれないまま動き出したときの水平化 | 1 秒 | 信用できる GNSS | `ESKF_YAW_INIT_MIN_SPEED_MPS` |

---

## 画面仕様と操作

### 画面各部の構成
* **画面上部**: 対地速度 (m/s)、推定 TAS（設定で平均迎角 `ᾱ` に切替）、真方位（`TT`）、速度精度（`sAcc`）。
  対地速度と真方位は、GNSS が断線した・fix していない・衛星 0 のとき赤い横線で消し、`NO GNSS` の札を載せる（読まない値。受信モードでは送信機の断線と fix で判断）。
* **画面中央**: 内蔵ベクタ地図（OSM 由来）、現在位置、航跡（緑線、最大 500 点 / 約 25km。跳躍 300m 以上は線引き除外）、パイロン基準線、コース警報アーク（向かうべき方位への赤線円弧）、旋回指示矢印（コースズレ 15° 以上で点滅）。
* **画面右上**: 無線（PONS Link）の強度・役割アイコンと `CH-SF-Group`（無線が ON のとき）。
* **自機アイコンの下（中央）**: ESKF のヨー 3 桁と、その真下にヨー精度（`Y95`）。
* **画面左下**: 平均ピッチ（`P̄`）、瞬時ピッチ（`P`）、ロール（`R`）、自動ロールトリム（`Rtrim`）。
* **画面右下**: 風速（`W`）と風向風速ベクトル矢印（吹いていく方向、色は風速）、風向 3 桁（吹いてくる真方位。矢印の中心）。
  TRACKUP では中央の `Y95` と重ならないよう風速を矢印の上に、NORTHUP では矢印の下に置く。
* **画面下部**: JST 時刻、最大対地速度（MAX GS。2 回連続の小さい方のみ採用）、目的地コース（TC）、目的地直線距離（km）、捕捉衛星数（10 以上で緑、9 以下は橙、4 以下は赤地。0 個は赤地に白字と白地に赤字を交互に点滅。分からないとき（受信を始めた直後・列の無いリプレイ）は灰色の `--sats`）、バッテリー残量（充電中 `CHG`、SW OFF 充電 `SW OFF`、無線ミラー中 `s72r85`）。
* **画面最下部**: ナビゲーションモード（`10K AWAY` / `10K INTO` / `FLY INTO` / `FLY AWAY`）、目的地名、SD 認識状態。

### 設定画面
NAV 画面でスイッチ長押しで入ります。
* 各行の右端のマークが設定状態を示します：**緑の丸＝本番推奨**、**赤の ×＝本番不可（デモやリプレイ等）**、**オレンジの三角＝許容だが既定外**（グレーのハイフンは対象外・OFF）。フッターの電池のマークは充電中が青の丸。**本番フライト前に赤の × が無いことを確認してください**。
* 地図拡大率は NAV 画面でボタンの**ダブルクリック**でも変更可能（標準縮尺 scaleindex=3 / 画面幅約 18km で緑）。
  * **受信モードでは送信機の縮尺に合わせません**（2026-11-12〜。ボートでは機体と違う縮尺で見られます）。
    `Map scale` の行の後ろに送信機の縮尺を `(S: 18km)` と添え、送信機の会場で縮尺が適切なら緑・要変更なら赤・まだ届いていなければ灰の `(S: --)` で出します。受信機自身の行の右端はハイフン（判定しない）です。
* 設定は SD の `settings.txt` に自動保存されますが、**DEMO / REPLAY モードは保存されません**（再起動すれば必ず本番航法へ復帰する安全設計）。
* **`REPLAY/DEMO`** の行から入る画面で、リプレイするファイルとデモの地点（BIWAKO / SHIRAHAMA / KASAOKA / FUJIGAWA / TOKYO / OSAKA）をまとめて選びます。短押しでカーソル移動、長押しで決定（その場で始めて地図画面へ）。先頭の `OFF (Normal GNSS)` でリプレイもデモも止まります。デモとリプレイは同時には使えず、どちらかを始めるともう片方は止まります。ファイルは新しいものが上に並びます（名前の日時 `YYYY-MM-DD_HHMM` の降順。日付で始まらない名前はその下に名前の順。Re:PONS の SD の一覧も同じく新しい日付が上で、日付ごとに見出しが付きます）。
* `Save & Exit >>` は他の行と見分けやすいよう中央に寄せてあります。
* 設定画面を 3 分操作しないと地図へ戻ります。設定画面を含め、**地図以外の画面（IMU/ESKF・GNSS 詳細・VARIO・WIRELESS など）を出したまま動き出すと**（自機の対地速度 2m/s 以上が 5 秒）、地図へ戻ります（降下する 2 音）。受信モードと PC 接続の画面は対象外です。
* **フッター（画面下 3 行）**: 電池（または充電の残り時間）、CPU・気圧センサーの温度、照度センサーと画面の明るさ。
  3 行目は `VEML 123lx  BL 35% AUTO` の形で、照度・いまの点灯率・その決まりを示します（右端のマークは照度センサーが応答していれば緑の丸、無ければ赤の ×）。
  起動画面の後半ページ（無線の結果）の右下にも `VEML:OK 123lx` / `VEML:NG` が出ます。

### READY になる条件

**まず機体で確認します。** NAV でスイッチを長押しすると、設定画面の右上に判定が出ます。

| 今見えている表示 | 次にすること |
|---|---|
| 機体に `NOT READY` | 続く項目名を確認。例えば `USB` なら機体の USB ケーブルを外す。`SCALE` なら下の会場表で縮尺を確認する。 |
| 機体に緑の `READY` | 機体のチェックは完了。初回はそのまま地上で静止し、「準備完了」の音声を確認する。 |
| ボート・ピットに `RX: SD` | ボート・ピットの受信機で SD カードの認識を確認する。 |
| ボート・ピットに `TX CFG: SCALE` | 機体側で地図の縮尺を確認する。受信機の拡大率は自由。 |
| ボート・ピットに `TX CFG: WAIT` | 送信機の設定結果を受信するまで待つ。表示が続けば、受信機の無線画面で無信号・グループ違い・送信機の重複を確認する。 |

待機中の NAV にも不足項目が出ます。`ESKF` や較正の案内が出たときは専用メッセージを確認します。デモ・リプレイは判定対象外です。

#### 1. 会場の設定を合わせる

| 会場 | 目的地（`DEST`） | 航法モード（`MODE`） | 地図の縮尺（`SCALE`） |
|---|---|---|---|
| 琵琶湖の大会 | `PLATHOME` | `Auto 10km` | 標準（画面幅約 18 km）のみ |
| 笠岡の試験飛行 | 同じ会場内。例：`KASAOKA03`、`KASAOKA21` | `Fly into` または `Fly away` | 全6段階で可 |
| 白浜の試験飛行 | 同じ会場内。例：`SHIRAHAMA16`、`SHIRAHAMA34` | `Fly into` または `Fly away` | 全6段階で可 |

笠岡・白浜は、自機の新しい測位が会場中心から半径 5 km 以内にあると自動で選ばれます。目的地も同じ会場の半径 5 km 以内から選びます。測位が古いときと両会場の外では、大会の設定基準を使います。

#### 2. 不足項目を確認する

| 画面の表示 | 機体で確認すること |
|---|---|
| `DEST`・`MODE`・`SCALE` | 上の表どおりに設定し、各行が緑の丸になること。 |
| `VOL`・`SET` | 効果音量 `Volume(SE)` は 30 以上。`SET` はその他の設定行の赤い ×。オレンジの三角は許容範囲。 |
| `GNSS` | 自機が有効な3D測位（`gnssFixOK`）を受け、水平位置精度が 5 m 以内。表示用測位の最終更新から 1.5 秒未満。 |
| `IMU` | SCH16T が応答していること。姿勢表示を OFF にしていても必要。 |
| `ESKF` | 姿勢推定が収束するまで機体を静止させる。 |
| `CALIB` | IMU / ESKF 画面でマウントと較正状態を確認する。 |
| `ATT` | 地上でのロール・ピッチが設定した許容範囲に入っているか確認する。 |
| `USB`・`BATT` | USB を外して電池で動作させる。電池残量は 50% 以上で、過放電ラッチと電源異常がないこと。 |
| `SD` | SD カードを認識し、使用できること。 |
| `LINK` | 送信モードでは無線モジュールが応答し、送信前チェックが実行中・スキップの状態でなく、同じチャンネルに同一または別グループの送信機を検出していないこと。雑音だけの警告は許容。無線 OFF では対象外。 |

`ESKF`・`CALIB`・`ATT` は姿勢機能が ON のときに確認します。

**「準備完了」の音声**は、上の全項目がそろい、自機の対地速度が **1.0 m/s 以下で5秒間**続くと1回鳴ります。時間は新しい測位で確認するため、最後の速度が残ったまま測位が止まっても発報しません。一度鳴った後は、不足が60秒以上続き、再び条件がそろって静止すると読み上げます。

#### 3. 受信機では RX と TX CFG を確認する

| 表示 | 確認している機器と条件 |
|---|---|
| `RX: OK` | 受信機自身の SD と電源が正常で、無線モジュールが応答し、重複のない送信を受信中。照合で送信機の目的地が受信機に見つからなければ `DEST`。電池動作時は残量 50% 以上。USB 給電も可。電源異常・高温充電・過放電ラッチは `BATT`。受信機自身の縮尺は自由。 |
| `TX CFG: OK` | 送信機が会場に応じて判定した目的地・航法モード・効果音量・縮尺・その他の設定がすべて適切。機体の GNSS・IMU・電池などを含む全体の `READY` は機体の設定画面で確認する。 |
| `TX CFG: WAIT` | 送信機の設定結果を確認できていない。起動直後の未受信、無信号、結果の期限切れ、送信機の重複など。 |

「準備完了」の音声は機体で鳴ります。無線データを解析するときは、[TX CFG のビット割り当てと復号例](docs/pons_link.md#tx-cfg-bits)を参照してください。

### 画面の明るさ（バックライト）
輝度スイッチと照度センサー（VEML7700、ケースカバー基板）で決まります。設定画面のフッターの名前で示します。

| 表示 | 条件 | 点灯率 |
|---|---|---|
| `SW BRIGHT` | 輝度スイッチ High | 常に 100%（待機中の減光もしない） |
| `AUTO` | 輝度スイッチ Low・照度センサーあり | 照度の対数で比例。曲線は設定画面の `AUTO Brightness` で選ぶ（下の表）。時定数 2 秒でゆっくり追う |
| `LAST LUX` | 照度センサーが途中で読めなくなった | 最後に読めた照度のまま（昼間に急に暗くしない） |
| `NO SENSOR` | 照度センサーが一度も読めていない | 5% 固定（待機中の減光に入っても表示はこのまま） |
| `IDLE DIM` | 待機中の自動減光（照度センサーがあるとき） | 5%（暗い所では `AUTO` の値を超えない） |

* **`AUTO Brightness`（設定画面。`settings.txt` の `auto_brightness:ECO` / `BRIGHT`、既定は ECO）**:

  | 照度（センサーの読み） | 10 lx | 100 lx | 1000 lx | 20000 lx | 50000 lx 以上 |
  |---|---|---|---|---|---|
  | `Eco` | 19% | 34% | 50% | 70% | 100% |
  | `Bright` | 35% | 68% | 100% | 100% | 100% |

  どちらも 1 lx 以下は 3%。Eco は曇りの昼間（約 20000 lx）を 70% で読めることを基準にしてあります。
  lx は窓越しのセンサーの読みなので照度計とは合いません。合わせるときはフッターの `VEML` の値を見てください（1 万 lx 以上は `21klx` のように k で出ます）。
  照度センサーは約 2900 lx を超えると感度を 1/32 に切り替え、約 12 万 lx まで測ります（1500 lx を下回ると戻す）。
* **待機中の自動減光**: 対地速度 0.3 m/s 未満・IMU が静止・照度が急に下がっていない、の 3 つが 30 秒続くと減光します。ボタン・輝度スイッチ High・対地速度 0.6 m/s 以上・IMU の動き・照度で見た手の動きで即座に戻り、戻ってから最低 30 秒は減光しません。減光中は画面の中央に `DIM MODE` と戻し方（動き出せば自動で戻る・ボタン・本体を叩くか動かす・センサーに手をかざす・輝度スイッチ High）を出します。地図以外の画面では、減光に入ったときの画面の上に重ね、減光の間はその画面を描き直しません（戻ると描き直します）。手の動きは次のどちらかです（変化量 5 lx 以上のときだけ）。
  * かざす: 直近 1 秒の最大から 50% 以上下がった。
  * あおぐ: 直近 1 秒の最大から 30% 以上下がり、そこから 1 秒以内に、いちばん暗い読みから 30% 以上明るくなった。

  照度は上限なしで、50 ms ごとに読んで比べます。20000 lx を超える晴れの日でも、手の影がセンサーにかかれば戻ります。雲の縁は数秒かけて暗くなったままなので、まず反応しません。1〜2 秒で通り過ぎる雲の切れ端では戻ることがありますが、30 秒明るくなるだけです。USB 給電中・リプレイ／デモ中・電源の警告中・地図に通知の箱が出ている間（受信機の NO SIGNAL を含む）は減光しません。
  受信機のミラー中は、上の 3 つに加えて**送信機も止まっている**（fix があって対地速度 0.3 m/s 未満）ことが条件です。送信機が 0.6 m/s 以上になるか fix を失うと戻ります。戻し方の 1 行目は `Plane or boat moves (auto)` になります。波で揺れるボートの上では IMU が静止にならないので減光しません。
* **電池低下**: 3.5V 以下で 4 秒点灯・4 秒消灯、3.0V 以下で 2 秒点灯・10 秒消灯をくり返します（点灯中はいつもの明るさ。フッターに `SAVER` / `SAVER2`）。
* 値は `settings.h` の `TFT_BL_*` / `BL_AUTO_*` / `BL_ECO_*` / `BL_DIM_*`、動きは `backlight.cpp`。

### IMU / ESKF 画面（点検と較正）
2 ページ構成（短押し＝カーソル移動、長押し＝実行）。操作する項目はすべて 1 ページ目にあります。
* **1 ページ目（点検手順）**:
  1. `SET PITCH`: 機体の現在ピッチ申告値（-3.5〜+2.0°、0.5° 刻み）。本番プラットホーム（-3.5°）でも申告値に合わせれば正確に水平較正可能。
  2. `SET ROLL`: ロール申告値（通常 0°。ウィングロー保持時のみ使用）。
  3. `APPLY`: ゼロ点較正の実行。ボタンを離してから 1 秒後に実行（ボタン押下による機体揺れを回避）。
  4. `Roll/Pitch/Yaw func`: 姿勢機能の一括 ON/OFF マスタースイッチ。
  5. `Roll trim during flight`: 直進中のロール自動トリムの ON/OFF。
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
## KiCad design kicad/case_cover/case_cover.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J2: Conn_01x04; FPC_CON 4p 1mm
LED1: VEML7700-TR; LED-SMD_4P-L6.8-W2.4_VEML7700-TR; MPN VEML7700-TR; LCSC Part C504893

Connections:
+3.3V: C1.1, J2.1, LED1.2 (VDD)
GND: C1.2, J2.4, LED1.3 (GND)
I2C0_SCL: J2.2, LED1.1 (SCL)
I2C0_SDA: J2.3, LED1.4 (SDA)

Board: 2 copper layers, 71.2 x 87.1 mm, 3 parts (0 on the bottom side), 4 nets.

## KiCad design kicad/mainboard/DisplayModule_PONSv71.kicad_pcb

Parts:
C1: 22u; C_0603_1608Metric; LCSC C59461
C2, C3, C6, C13, C49, C50, C51: 1u; C_0402_1005Metric_small_pads; LCSC C52923
C4, C15, C33, C35: 100n; C_0402_1005Metric_small_pads; LCSC C1525
C7, C14: 47u; C_0805_2012Metric; LCSC C16780
C8, C10: 220p; C_0402_1005Metric_small_pads; LCSC C1530
C9: 100u; C_1206_3216Metric; LCSC C15008
C11, C39, C41: 10u; C_0402_1005Metric_small_pads; LCSC C15525
C32: 10u; C_0805_2012Metric; LCSC C15850
C37, C40: 4.7u 16V; C_0603_1608Metric; LCSC C19666
D1: VBUS_LED_W; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2290
D2, D4: LED_R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286
D3: 1N5819WS; D_SOD-323; LCSC C191023
D6, D7: LED_R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2286; not fitted
D8: VBUS_LED_W; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C2290; not fitted
F1: 0805L050; Fuse_0805_2012Metric; LCSC C207022
FB1, FB2: 600; L_0805_2012Metric; LCSC C1017
H1, H2, H3, H4: MountingHole; MountingHole_2.7mm_M2.5
J1: Ext. Speaker; PinHeader_1x02_P2.54mm_Vertical
J2: 54132-4062; MOLEX_54132-4062; PARTREV G; LCSC C505102
J3: Micro_SD_Card_Det2; microSD_HC_Hirose_DM3AT-SF-PEJM5; LCSC C114218
J5: Ext. Speaker; TestPoint_Pad_1.5x1.5mm_double
J9: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
L2: 1.5u; L_APV_ANR3015; LCSC C701165
PWR1: 1s Lipo Power input; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal; LCSC C173752
Q1, Q2, Q3, Q4: AO3401A; SOT-23; LCSC C15127
R1, R4: 1k; R_0402_1005Metric; LCSC C11702
R2, R34, R37: 10k; R_0402_1005Metric; LCSC C25744
R3: 470; R_0402_1005Metric; LCSC C25117
R5, R6, R11: 100; R_0402_1005Metric; LCSC C25076
R7, R38, R47: 100k; R_0402_1005Metric; LCSC C25741
R8, R40: 200; R_0402_1005Metric; LCSC C25087
R10: 1; R_0603_1608Metric; LCSC C22936
R12, R13, R14, R15, R16, R17: 33; R_0402_1005Metric; LCSC C25105
R18, R19, R20, R21, R22: 4.7k; R_0402_1005Metric; LCSC C25900
R35, R45, R46: 5.1k; R_0402_1005Metric; LCSC C25905
R39: 3.3k; R_0402_1005Metric; LCSC C25890
SW4: MST-12D18G2 SMD SLIDE SWITCH; SW-SMD_3P-L9.1-W3.5-P2.50_MST-12D18G2; MPN MST-12D18G2 SMD Slide Switch; LCSC C49023765
U1: PAM8302AASCR; MSOP-8_3x3mm_P0.65mm; LCSC C113367
U4: TPS63031DSK; WSON-10-1EP_2.5x2.5mm_P0.5mm_EP1.2x2mm; LCSC C15516
U5: MCP73831-2-OT; SOT-23-5; LCSC C424093
U10, U11: NCP360SNT1G; TSOP-5_1.65x3.05mm_P0.95mm; LCSC C603707
U12: USBLC6-2SC6; SOT-23-6; LCSC C5261088

Connections:
+3V3: C6.1, C7.1, C9.1, C11.1, C13.1, C14.1, C15.1, C39.1, C41.1, J2.28, J2.33, J2.34, J3.4 (VDD), Q1.2 (S), R18.2, R19.2, R20.2, R21.2, R22.2, R47.1, U1.6 (VDD), U4.1 (VOUT), U4.10 (FB); also elsewhere on the board
/GATE_Q3Q4: C33.2, Q3.1 (G), Q4.1 (G), R37.1, R38.2
/VBAT_THERMAL: C40.1, F1.1, U5.3 (V_{BAT})
ADC0: SW4.3; also elsewhere on the board
AMP_SD: R7.1, U1.1 (~SD); also elsewhere on the board
BATPWR: F1.2, Q2.3 (D), Q3.3 (D); also elsewhere on the board
DB0: J2.27; also elsewhere on the board
DB1: J2.26; also elsewhere on the board
DB2: J2.25; also elsewhere on the board
DB3: J2.24; also elsewhere on the board
DB4: J2.23; also elsewhere on the board
DB5: J2.22; also elsewhere on the board
DB6: J2.21; also elsewhere on the board
DB7: J2.20; also elsewhere on the board
DB8: J2.19; also elsewhere on the board
DB9: J2.18; also elsewhere on the board
DB10: J2.17; also elsewhere on the board
DB11: J2.16; also elsewhere on the board
DB12: J2.15; also elsewhere on the board
DB13: J2.14; also elsewhere on the board
DB14: J2.13; also elsewhere on the board
DB15: J2.12; also elsewhere on the board
GND: C3.1, C4.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C32.2, C35.2, C37.2, C39.2, C40.2, C41.2, C49.2, C50.1, C51.1, D1.1 (K), D2.1 (K), D7.1 (K), D8.1 (K), J2.2, J2.4, J2.5, J2.6, J2.7, J2.8, J2.9, J2.10, J2.31, J2.40, J3.6 (VSS), J3.9 (DET_B), J3.SH (SHIELD), J9.A1 (GND), J9.A12 (GND), J9.B1 (GND), J9.B12 (GND), J9.SH (SHIELD), PWR1.2, R2.1, R7.2, R35.2, R39.2, R45.2, R46.2, SW4.2, U1.7 (GND), U4.3 (PGND), U4.9 (GND), U4.11 (PGND), U5.2 (V_{SS}), U10.2 (GND), U10.3 (~EN), U12.2 (GND); also elsewhere on the board
unnamed: C2.1, R1.1, R2.2
unnamed: C2.2, R5.1
unnamed: C3.2, R6.1
unnamed: C4.2, R1.2, R4.1
unnamed: D1.2 (A), D8.2 (A), R3.2
unnamed: D2.2 (A), D7.2 (A), R8.2
unnamed: C1.2, D4.2 (A), D6.2 (A), R40.2
unnamed: C1.1, D4.1 (K), D6.1 (K), U5.1 (STAT)
unnamed: C8.1, FB2.2, J1.1, J5.1
unnamed: C10.1, FB1.2, J1.2, J5.2
unnamed: J2.3, R10.2
unnamed: J3.5 (CLK), R15.2
unnamed: J3.3 (CMD), R14.2, R20.1
unnamed: J3.7 (DAT0), R16.2, R21.1
unnamed: J3.8 (DAT1), R17.2, R22.1
unnamed: J3.1 (DAT2), R12.2, R18.1
unnamed: J3.2 (DAT3/CD), R13.2, R19.1
unnamed: J9.A5 (CC1), R45.1
unnamed: J9.B5 (CC2), R46.1
unnamed: J9.A6 (D+), J9.B6 (D+), U12.3 (I/O2)
unnamed: J9.A7 (D-), J9.B7 (D-), U12.1 (I/O1)
unnamed: Q1.3 (D), R10.1
unnamed: Q1.1 (G), R11.1, R47.2
unnamed: C33.1, Q3.2 (S), Q4.2 (S), R38.1
unnamed: R5.2, U1.3 (IN+)
unnamed: R6.2, U1.4 (IN-)
unnamed: FB1.1, U1.5 (OUT+)
unnamed: FB2.1, U1.8 (OUT-)
unnamed: C35.1, U4.6 (EN), U4.7 (PS/SYNC), U4.8 (VINA)
unnamed: L2.1, U4.4 (L1)
unnamed: L2.2, U4.2 (L2)
unnamed: R39.1, U5.5 (PROG)
unnamed: C51.2, J9.A4 (VBUS), J9.A9 (VBUS), J9.B4 (VBUS), J9.B9 (VBUS), U10.1 (IN)
PWM_AUDIO: R4.2; also elsewhere on the board
PWR_GATE_SW: R37.2, SW4.1
SD_CLK: R15.1; also elsewhere on the board
SD_CMD: R14.1; also elsewhere on the board
SD_DAT0: R16.1; also elsewhere on the board
SD_DAT1: R17.1; also elsewhere on the board
SD_DAT2: R12.1; also elsewhere on the board
SD_DAT3: R13.1; also elsewhere on the board
SD_DETA: J3.10 (DET_A); also elsewhere on the board
TFT_DC: J2.30; also elsewhere on the board
TFT_MOSFET_G: R11.2; also elsewhere on the board
TFT_RESET: J2.11; also elsewhere on the board
TFT_WR: J2.29; also elsewhere on the board
USB_D+: U12.4 (I/O2); also elsewhere on the board
USB_D-: U12.6 (I/O1); also elsewhere on the board
USB_SENS: C49.1, R34.2, R35.1; also elsewhere on the board
USR_LED: R8.1; also elsewhere on the board
VBAT_RAW: PWR1.1, Q4.3 (D); also elsewhere on the board
VBUS_5V: C37.1, C50.2, D3.2 (A), Q2.1 (G), R3.1, R34.1, R40.1, U5.4 (V_{DD}), U10.5 (OUT)
VSYS: C32.1, D3.1 (K), Q2.2 (S), U4.5 (VIN); also elsewhere on the board

Notes on the sheet:
(5V-3.0V)/470 Ohm =4.2mA
USB surge protection.
Q4: 電池の逆接保護（D が電池側） USB を挿したままの逆接は守れない
SDIO
V7.1 初期版は Q4 G は、抵抗GND
[Memo JLCPCB BOM Exemption] J1 Speaker socket (No parts required) J4 Debug SH 3p(No use. Debug purpose) U9 E220 LoRa (Due to 技適, 手実装) H1,H2,H3,H4 Hole
For parts handling...
(3.3V-2.0V)/200 Ohm=6.5mA
Recommend GC0351M-ND
Power
Q2: Bat Discharger For Battery Safety
(5V-2.0V)/200Ohm=15mA
SPEAKER
GZ2012D601TF
BAT IN
2.2k to limit current
Lipo Charger
(0.1uF+1kΩ Acceptable)
TFT NHD-2.8-240320AF-CSXP-F
Q3: ユーザー電源スイッチ
Grounding P-Ch FET Gate float at the same time
C1 Shuts off the LED when CHG ON/OFF alternating CHG due to leak current flow of BATPWR-R32(100kOhm)-SW-GND

Parts:
BT1: MS621FE; BatteryHolder_Seiko_MS621F
C42: 100u; C_1206_3216Metric; LCSC C15008
C43, C44, C46, C47, C48, C52, C55: 100n; C_0402_1005Metric_small_pads; LCSC C1525
C45: 10u; C_0402_1005Metric_small_pads; LCSC C15525
C53, C54: 4.7u; C_0402_1005Metric_small_pads; LCSC C23733
D5, D9: RB751S40; D_SOD-523; LCSC C232576
J6: Conn_01x08_MountingPin; Molex_200528-0080_1x08-1MP_P1.00mm_Horizontal
J7: 2005280050; Molex_200528-0050_1x05-1MP_P1.00mm_Horizontal; MANUFACTURER_PART_NUMBER 2005280050
J8: 2005280040; Molex_200528-0040_1x04-1MP_P1.00mm_Horizontal; MANUFACTURER_PART_NUMBER 2005280040
Q5: AO3401A; SOT-23; LCSC C15127
R41, R42: 4.7k; R_0402_1005Metric; LCSC C25900
R43, R55: 220; R_0402_1005Metric; LCSC C25091
R44: 470; R_0402_1005Metric; LCSC C25117
R49, R50, R51: 33; R_0402_1005Metric; LCSC C25105
R52: 4.7M; R_0603_1608Metric; LCSC C23163
R53: 47k; R_0402_1005Metric; LCSC C25792
R54: 2.2M; R_0603_1608Metric; LCSC C22938
R56: 100k; R_0402_1005Metric; LCSC C25741
R57: 330; R_0402_1005Metric; LCSC C25104
R58: 10k; R_0402_1005Metric; LCSC C25744
TP1: TestPoint_2Pole; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
U6: MIC841HYC5; SOT-353_SC-70-5; LCSC C511290
U7: RT9078-33GJ5; TSOT-23-5; LCSC C110427
U8: MS5611-01BA; LGA-8_3x5mm_P1.25mm; LCSC C15639
U9: E220-900T22S(JP)

Connections:
+3V3: C43.1, C48.1, J6.8, J7.1, J8.1, R41.1, R42.1, R43.1, U8.1 (VDD), U8.2 (PS); also elsewhere on the board
GND: BT1.2 (-), C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C52.2, C53.2, C54.2, C55.2, J6.1, J6.MP (MountPin), J7.2, J7.MP (MountPin), J8.4, J8.MP, R54.2, R56.1, U6.2 (GND), U7.2 (GND), U8.3 (GND), U8.4 (CSB), U8.5 (CSB), U9.1 (GND), U9.2 (GND), U9.3 (GND), U9.4 (GND), U9.11 (GND), U9.13 (GND), U9.19 (GND), U9.20 (GND), U9.22 (GND); also elsewhere on the board
I2C0_SCL: J8.2, R41.2, U8.8 (SCLK); also elsewhere on the board
I2C0_SDA: J8.3, R42.2, U8.7 (SDI/SDA); also elsewhere on the board
LORA_AUX: C46.1, U9.9 (AUX); also elsewhere on the board
LORA_M01: U9.5 (M0), U9.6 (M1); also elsewhere on the board
unnamed: BT1.1 (+), R44.2
unnamed: D5.2 (A), R43.2
unnamed: D9.2 (A), R55.2
unnamed: J6.4, R49.2
unnamed: J6.5, R50.2
unnamed: J6.6, R51.2
unnamed: Q5.1 (G), R56.2
unnamed: Q5.2 (S), R52.1, R57.1, R58.2
unnamed: R53.1, R54.1, U6.1 (HTH)
unnamed: C52.1, R52.2, R53.2, U6.3 (LTH)
unnamed: U6.4 (OUT), U7.3 (EN)
unnamed: C55.1, R58.1, U6.5 (VDD)
unnamed: C53.1, R57.2, U7.1 (VIN)
unnamed: C54.1, R55.1, U7.5 (VOUT)
unnamed: TP1.2, U9.14 (SWCLK)
unnamed: TP1.1, U9.12 (SWDIO)
SCH16T_RESET: J6.7; also elsewhere on the board
SCH16T_SYNC: J6.3; also elsewhere on the board
SPI1_CS: R50.1; also elsewhere on the board
SPI1_RX_MISO: J6.2; also elsewhere on the board
SPI1_SCK: R49.1; also elsewhere on the board
SPI1_TX_MOSI: R51.1; also elsewhere on the board
UART0_RX: J7.3; also elsewhere on the board
UART0_TX: J7.4; also elsewhere on the board
UART1_RX: U9.8 (TXD); also elsewhere on the board
UART1_TX: U9.7 (RXD); also elsewhere on the board
VBAT_RAW: Q5.3 (D); also elsewhere on the board
VSYS: C42.1, C44.1, C45.1, U9.10 (VCC); also elsewhere on the board
V_BCKUP: C47.1, D5.1 (K), D9.1 (K), J7.5, R44.1

Notes on the sheet:
ショート保険
突入電流&バッテリー電流制限&最小 V_BCKP 対策
Battery 3.8V Cut-off GNSS V_BCKUP Charger
BT1が放電しきっていても、即座にGNSSが起動できる電圧をV_BCKUPに提供する V_BCKP Minimum operating voltage = 1.65V 抵抗によって、BT1バッテリーが空っぽでも、V_BCKUPに電圧が生じる((3.3-0.6)*470/690)=1.8Vぐらい 放電時の電圧降下はV=IR=10*10^-6*470 で、電圧降下はほとんどない P=IV=V^2/R=(0.5*10^-3)^2/500=0.5*10^-9=0.5nW
I2C address select
I2C(AMBIENT LIGHT SENSOR VEML7700)
LORA_TX
GNSS CONNECTOR Socket substitute:0522710479
LORA_RX
LORA
IMU
EXTERNAL CONNECTORS
Q5: 逆接保護
MS5611

Notices in the files:
README.md:
**ソースコード本体** (`*.ino`, `*.cpp`, `*.h`, `tools/*.py`): [MIT License](LICENSE)
Map data © OpenStreetMap contributors
